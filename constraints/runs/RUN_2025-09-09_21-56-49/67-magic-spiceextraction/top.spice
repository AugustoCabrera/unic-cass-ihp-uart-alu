* NGSPICE file created from top.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_1 abstract view
.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_4 abstract view
.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

.subckt top i_clk i_reset i_uartRx o_uartTx vccd1 vssd1
XuartUnit.uartTxUnit._164_ net51 uartUnit.uartTxUnit._009_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.n\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._095_ net16 uartUnit.uartTxUnit._053_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit._002_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_17_191 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_148 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_37_Left_86 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._157_ net33 alu_uart_interfaceUnit._074_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._022_ sky130_fd_sc_hd__and2_1
XFILLER_36_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_3_78 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.fifoTX._170_ net59 uartUnit.fifoTX._036_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._147_ net8 net6 uartUnit.uartTxUnit._022_ uartUnit.uartTxUnit._034_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._035_ sky130_fd_sc_hd__or4_1
XuartUnit.uartTxUnit._078_ net14 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._040_
+ sky130_fd_sc_hd__inv_2
XFILLER_12_65 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_18_247 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_41_261 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._209_ net55 alu_uart_interfaceUnit._021_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[7\] sky130_fd_sc_hd__dfxtp_2
XaluUnit._282_ aluUnit._103_ aluUnit._112_ aluUnit._029_ vssd1 vssd1 vccd1 vccd1 aluUnit._048_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_5_151 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoTX._084_ uartUnit.fifoTX.array\[2\]\[6\] alu_uart_interfaceUnit.o_data_to_write\[6\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._008_ sky130_fd_sc_hd__mux2_1
XFILLER_15_206 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._153_ net58 uartUnit.fifoTX._019_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_30_209 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_348 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap5 uartUnit.uartTxUnit._023_ vssd1 vssd1 vccd1 vccd1 net5 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._196_ aluUnit.i_data_a\[0\] net29 aluUnit._126_ aluUnit._128_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._129_ sky130_fd_sc_hd__o2bb2a_1
XaluUnit._265_ net21 net31 aluUnit._124_ aluUnit._031_ vssd1 vssd1 vccd1 vccd1 aluUnit._032_
+ sky130_fd_sc_hd__o22a_1
XFILLER_14_261 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_14_283 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_259 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_73 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._110_ uartUnit.uartRxUnit.state\[2\] uartUnit.uartRxUnit._039_
+ uartUnit.uartRxUnit._040_ uartUnit.uartRxUnit.state\[0\] uartUnit.uartRxUnit.state\[3\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._058_ sky130_fd_sc_hd__a2111oi_4
XTAP_TAPCELL_ROW_22_215 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_20_286 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_329 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_53 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_7_213 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_11_220 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_11_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._136_ net57 uartUnit.fifoTX._002_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._067_ alu_uart_interfaceUnit.o_fifo_tx_write vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoTX._044_ sky130_fd_sc_hd__inv_2
XFILLER_7_268 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_38_128 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._317_ net25 aluUnit._117_ aluUnit._134_ vssd1 vssd1 vccd1 vccd1 aluUnit._081_
+ sky130_fd_sc_hd__or3_1
XaluUnit._248_ net23 net32 aluUnit._124_ aluUnit._015_ vssd1 vssd1 vccd1 vccd1 aluUnit._016_
+ sky130_fd_sc_hd__o22ai_1
XaluUnit._179_ net23 aluUnit._105_ vssd1 vssd1 vccd1 vccd1 aluUnit._112_ sky130_fd_sc_hd__nor2_1
Xfanout7 uartUnit.uartTxUnit._047_ vssd1 vssd1 vccd1 vccd1 net7 sky130_fd_sc_hd__buf_2
Xalu_uart_interfaceUnit._190_ net47 alu_uart_interfaceUnit._002_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.state\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_238 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_43_186 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_35_109 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_310 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._119_ uartUnit.fifoTX._044_ uartUnit.fifoTX.i_read_fifo uartUnit.fifoTX._058_
+ uartUnit.fifoTX._059_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._060_ sky130_fd_sc_hd__or4_1
XFILLER_13_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_34_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_34_153 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Left_60 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_40_156 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_15_43 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._173_ net37 alu_uart_interfaceUnit._082_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._030_ sky130_fd_sc_hd__and2_1
XFILLER_48_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_16_131 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_16_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._097_ uartUnit.fifoRX.array\[1\]\[1\] uartUnit.fifoRX.i_data_to_write\[1\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._019_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._166_ net50 uartUnit.fifoRX._032_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.o_fifo_is_full
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._163_ net51 uartUnit.uartTxUnit._008_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.n\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_245 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._094_ uartUnit.tx_not_empty uartUnit.uartTxUnit.state\[0\] uartUnit.uartTxUnit._046_
+ uartUnit.uartTxUnit.state\[2\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._053_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_17_192 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_149 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._156_ aluUnit.i_data_b\[0\] alu_uart_interfaceUnit.i_data_to_read\[0\]
+ alu_uart_interfaceUnit._053_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._074_
+ sky130_fd_sc_hd__mux2_1
XFILLER_13_145 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_26_42 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._225_ net57 alu_uart_interfaceUnit._037_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_42_41 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_3_35 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_173 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._149_ net47 uartUnit.fifoRX._015_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._146_ uartUnit.fifoTX.o_data_to_read\[5\] uartUnit.uartTxUnit.send_byte\[6\]
+ net15 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._034_ sky130_fd_sc_hd__mux2_1
XFILLER_35_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._077_ uartUnit.uartTxUnit.s\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._039_
+ sky130_fd_sc_hd__inv_2
XFILLER_10_104 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_12_77 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_130 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_41 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_243 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_273 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
Xalu_uart_interfaceUnit._139_ aluUnit.i_op\[5\] alu_uart_interfaceUnit._051_ alu_uart_interfaceUnit._065_
+ net33 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._013_ sky130_fd_sc_hd__o211a_1
XaluUnit._281_ aluUnit._042_ aluUnit._045_ vssd1 vssd1 vccd1 vccd1 aluUnit._047_ sky130_fd_sc_hd__nand2_1
Xalu_uart_interfaceUnit._208_ net54 alu_uart_interfaceUnit._020_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_5_185 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_5_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_17_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Right_12 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_Right_21 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartTxUnit._129_ uartUnit.uartTxUnit._040_ uartUnit.uartTxUnit._041_ uartUnit.uartTxUnit._044_
+ uartUnit.uartTxUnit._056_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._022_ sky130_fd_sc_hd__o31ai_4
XuartUnit.fifoTX._083_ uartUnit.fifoTX.array\[2\]\[5\] alu_uart_interfaceUnit.o_data_to_write\[5\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._007_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoTX._152_ net57 uartUnit.fifoTX._018_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_15_218 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_23_240 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Right_30 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_349 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._333_ aluUnit._126_ aluUnit._088_ aluUnit._089_ aluUnit._095_ vssd1 vssd1
+ vccd1 vccd1 aluUnit.o_alu_result\[7\] sky130_fd_sc_hd__a31o_1
XaluUnit._195_ aluUnit._127_ vssd1 vssd1 vccd1 vccd1 aluUnit._128_ sky130_fd_sc_hd__inv_2
XFILLER_9_23 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._264_ net21 net31 aluUnit._127_ vssd1 vssd1 vccd1 vccd1 aluUnit._031_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_43_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_20_232 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_216 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_107 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_18_65 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_90 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._135_ uartUnit.fifoTX.read_ptr\[1\] uartUnit.fifoTX._050_ uartUnit.fifoTX._052_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._031_ sky130_fd_sc_hd__o21a_1
XuartUnit.fifoTX._066_ alu_uart_interfaceUnit.i_fifo_tx_full vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoTX._043_ sky130_fd_sc_hd__inv_2
XFILLER_7_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_11_243 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._316_ aluUnit.i_data_b\[6\] aluUnit.i_data_a\[6\] aluUnit._133_ aluUnit._079_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._080_ sky130_fd_sc_hd__a31o_1
Xfanout8 uartUnit.uartTxUnit._047_ vssd1 vssd1 vccd1 vccd1 net8 sky130_fd_sc_hd__dlymetal6s2s_1
XaluUnit._247_ net23 net32 aluUnit._127_ vssd1 vssd1 vccd1 vccd1 aluUnit._015_ sky130_fd_sc_hd__a21oi_1
XaluUnit._178_ aluUnit.i_data_b\[3\] net22 vssd1 vssd1 vccd1 vccd1 aluUnit._111_ sky130_fd_sc_hd__nor2_1
XFILLER_29_53 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_43_154 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_43_110 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_311 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._118_ uartUnit.fifoTX.read_ptr\[0\] uartUnit.fifoTX.write_ptr\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._059_ sky130_fd_sc_hd__xnor2_1
XFILLER_28_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_34_165 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_1_209 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_15_22 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._172_ alu_uart_interfaceUnit.o_data_to_write\[0\] aluUnit.o_alu_result\[0\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._082_
+ sky130_fd_sc_hd__mux2_1
XFILLER_40_168 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._165_ net50 uartUnit.fifoRX._031_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.read_ptr\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_31_102 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_31_179 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._096_ uartUnit.fifoRX.array\[1\]\[0\] uartUnit.fifoRX.i_data_to_write\[0\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._018_ sky130_fd_sc_hd__mux2_1
XFILLER_39_257 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartTxUnit._162_ net56 uartUnit.uartTxUnit._007_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.s\[3\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._093_ uartUnit.uartTxUnit._051_ uartUnit.uartTxUnit._052_ net40
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._001_ sky130_fd_sc_hd__a21oi_1
XFILLER_42_20 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_13_102 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_13_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._155_ aluUnit.i_data_a\[7\] alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._073_
+ net36 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._021_ sky130_fd_sc_hd__o211a_1
Xalu_uart_interfaceUnit._224_ net57 alu_uart_interfaceUnit._036_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_282 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_29_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._148_ net42 uartUnit.fifoRX._014_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_14_174 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._079_ uartUnit.fifoRX.array\[2\]\[1\] uartUnit.fifoRX.i_data_to_write\[1\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._003_ sky130_fd_sc_hd__mux2_1
XFILLER_27_238 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._145_ uartUnit.uartTxUnit.send_byte\[4\] net5 uartUnit.uartTxUnit._033_
+ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._015_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_37_288 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_260 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_10_116 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_10_149 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_12_45 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_131 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_53 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_33_219 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._280_ aluUnit._042_ aluUnit._045_ vssd1 vssd1 vccd1 vccd1 aluUnit._046_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_28_244 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._138_ alu_uart_interfaceUnit.i_data_to_read\[5\] net20 alu_uart_interfaceUnit._050_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._065_ sky130_fd_sc_hd__or3_1
Xalu_uart_interfaceUnit._207_ net54 alu_uart_interfaceUnit._019_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[5\] sky130_fd_sc_hd__dfxtp_2
XFILLER_5_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_200 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._59_ uartUnit.baud_rateUnit.counter\[7\] uartUnit.baud_rateUnit.counter\[6\]
+ uartUnit.baud_rateUnit._19_ uartUnit.baud_rateUnit._24_ uartUnit.baud_rateUnit.counter\[8\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._29_ sky130_fd_sc_hd__a41o_1
XFILLER_32_285 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoTX._151_ net56 uartUnit.fifoTX._017_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._128_ uartUnit.uartTxUnit.n\[2\] uartUnit.uartTxUnit._074_ uartUnit.uartTxUnit._021_
+ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._010_ sky130_fd_sc_hd__o211a_1
XuartUnit.fifoTX._082_ uartUnit.fifoTX.array\[2\]\[4\] alu_uart_interfaceUnit.o_data_to_write\[4\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._006_ sky130_fd_sc_hd__mux2_1
XFILLER_23_44 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_23_66 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_3_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_48_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_48_41 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_2_189 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_0_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_9_13 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_9_35 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_14_241 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._263_ aluUnit._029_ vssd1 vssd1 vccd1 vccd1 aluUnit._030_ sky130_fd_sc_hd__inv_2
XaluUnit._332_ aluUnit._091_ aluUnit._093_ aluUnit._094_ vssd1 vssd1 vccd1 vccd1 aluUnit._095_
+ sky130_fd_sc_hd__or3b_1
XaluUnit._194_ aluUnit._119_ aluUnit._123_ vssd1 vssd1 vccd1 vccd1 aluUnit._127_ sky130_fd_sc_hd__or2_2
XFILLER_9_57 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_36_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_20_200 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_217 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._134_ uartUnit.fifoTX.read_ptr\[0\] uartUnit.fifoTX._049_ uartUnit.fifoTX._051_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._030_ sky130_fd_sc_hd__o21a_1
XFILLER_18_77 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.uartRxUnit._099_ uartUnit.uartRxUnit._046_ uartUnit.uartRxUnit._047_ uartUnit.uartRxUnit.s\[1\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._050_ sky130_fd_sc_hd__o21a_1
XuartUnit.fifoTX._065_ uartUnit.fifoTX.o_fifo_is_empty vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._042_
+ sky130_fd_sc_hd__inv_2
XFILLER_11_211 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_11_277 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_46_152 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._246_ aluUnit._112_ aluUnit._009_ aluUnit._012_ aluUnit._013_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._014_ sky130_fd_sc_hd__a22o_1
XaluUnit._315_ aluUnit.i_data_b\[6\] aluUnit.i_data_a\[6\] aluUnit._131_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._079_ sky130_fd_sc_hd__nor3_1
Xfanout9 uartUnit.baud_rateUnit.o_tick vssd1 vssd1 vccd1 vccd1 net9 sky130_fd_sc_hd__clkbuf_4
XaluUnit._177_ aluUnit.i_data_a\[0\] aluUnit.i_data_a\[1\] aluUnit.i_data_a\[2\] aluUnit.i_data_a\[3\]
+ net29 net27 vssd1 vssd1 vccd1 vccd1 aluUnit._110_ sky130_fd_sc_hd__mux4_1
XFILLER_28_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_43_166 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_312 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._117_ uartUnit.fifoTX.read_ptr\[1\] uartUnit.fifoTX._057_ vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoTX._058_ sky130_fd_sc_hd__xnor2_1
XFILLER_19_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_19_152 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_34_177 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._229_ net22 aluUnit._160_ vssd1 vssd1 vccd1 vccd1 aluUnit._161_ sky130_fd_sc_hd__nand2_1
XFILLER_15_67 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
Xalu_uart_interfaceUnit._171_ net35 alu_uart_interfaceUnit._081_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._029_ sky130_fd_sc_hd__and2_1
XFILLER_25_166 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_48_225 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_0_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_16_155 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_16_177 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._095_ uartUnit.fifoRX.write_ptr\[1\] uartUnit.fifoRX.write_ptr\[0\]
+ uartUnit.fifoRX._045_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._048_ sky130_fd_sc_hd__and3b_4
XuartUnit.fifoRX._164_ net50 uartUnit.fifoRX._030_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.read_ptr\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_39_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.uartTxUnit._161_ net56 uartUnit.uartTxUnit._006_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.s\[2\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._092_ uartUnit.uartTxUnit.state\[2\] uartUnit.uartTxUnit._045_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._052_ sky130_fd_sc_hd__nand2_1
Xalu_uart_interfaceUnit._223_ net58 alu_uart_interfaceUnit._035_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_107 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._154_ alu_uart_interfaceUnit.i_data_to_read\[7\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._073_ sky130_fd_sc_hd__or2_1
XFILLER_26_88 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_3_15 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.fifoRX._078_ uartUnit.fifoRX.array\[2\]\[0\] uartUnit.fifoRX.i_data_to_write\[0\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._002_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._147_ net42 uartUnit.fifoRX._013_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_8_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_175 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._144_ net8 net6 uartUnit.uartTxUnit._022_ uartUnit.uartTxUnit._032_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._033_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_37_289 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_272 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_132 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_65 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._206_ net54 alu_uart_interfaceUnit._018_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[4\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_28_245 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._137_ aluUnit.i_op\[4\] alu_uart_interfaceUnit._051_ alu_uart_interfaceUnit._064_
+ net33 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._012_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_19_201 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_209 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.baud_rateUnit._58_ uartUnit.baud_rateUnit._25_ uartUnit.baud_rateUnit._28_
+ uartUnit.baud_rateUnit._27_ uartUnit.baud_rateUnit._15_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit._07_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_2_113 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._150_ net56 uartUnit.fifoTX._016_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_23_220 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.uartTxUnit._127_ net14 uartUnit.uartTxUnit._050_ uartUnit.uartTxUnit._054_
+ uartUnit.uartTxUnit._069_ uartUnit.uartTxUnit._071_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._021_
+ sky130_fd_sc_hd__a2111o_1
XuartUnit.fifoTX._081_ uartUnit.fifoTX.array\[2\]\[3\] alu_uart_interfaceUnit.o_data_to_write\[3\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._005_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_270 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_78 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_2_146 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_2_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_48_97 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_48_53 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_0_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._193_ aluUnit.i_op\[0\] aluUnit._125_ vssd1 vssd1 vccd1 vccd1 aluUnit._126_
+ sky130_fd_sc_hd__nor2_2
XFILLER_14_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XaluUnit._262_ aluUnit.i_data_a\[7\] aluUnit._111_ aluUnit._108_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._029_ sky130_fd_sc_hd__o21ai_2
XaluUnit._331_ net30 net25 aluUnit._116_ aluUnit._134_ vssd1 vssd1 vccd1 vccd1 aluUnit._094_
+ sky130_fd_sc_hd__or4_1
XFILLER_29_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_340 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_212 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._133_ uartUnit.fifoTX.array\[3\]\[7\] alu_uart_interfaceUnit.o_data_to_write\[7\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._041_ sky130_fd_sc_hd__mux2_1
XFILLER_34_11 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartRxUnit._098_ uartUnit.uartRxUnit._027_ uartUnit.uartRxUnit._046_ uartUnit.uartRxUnit._047_
+ uartUnit.uartRxUnit._049_ net18 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._004_
+ sky130_fd_sc_hd__o311a_1
XFILLER_11_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_46_186 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Left_77 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._245_ net25 aluUnit._117_ aluUnit._121_ net23 vssd1 vssd1 vccd1 vccd1 aluUnit._013_
+ sky130_fd_sc_hd__or4b_1
XaluUnit._176_ aluUnit.i_data_b\[3\] aluUnit._097_ aluUnit._108_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._109_ sky130_fd_sc_hd__a21boi_1
XaluUnit._314_ aluUnit.i_data_b\[6\] aluUnit.i_data_a\[6\] aluUnit._124_ aluUnit._077_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._078_ sky130_fd_sc_hd__o22a_1
XFILLER_20_68 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_43_134 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_28_153 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._116_ uartUnit.fifoTX.write_ptr\[1\] uartUnit.fifoTX.write_ptr\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._057_ sky130_fd_sc_hd__xnor2_1
XFILLER_19_120 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_34_189 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_19_164 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._228_ net26 aluUnit._154_ aluUnit._159_ vssd1 vssd1 vccd1 vccd1 aluUnit._160_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_40_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_40_126 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_15_57 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._170_ aluUnit.i_data_b\[7\] alu_uart_interfaceUnit.i_data_to_read\[7\]
+ alu_uart_interfaceUnit._053_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._081_
+ sky130_fd_sc_hd__mux2_1
XFILLER_48_237 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_277 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_16_112 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._094_ uartUnit.fifoRX.i_data_to_write\[7\] uartUnit.fifoRX.array\[0\]\[7\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._017_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._163_ net44 uartUnit.fifoRX._029_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.write_ptr\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_47_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_11_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartTxUnit._160_ net62 uartUnit.uartTxUnit._005_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.s\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._091_ net10 uartUnit.uartTxUnit._044_ uartUnit.uartTxUnit._049_
+ uartUnit.uartTxUnit._040_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._051_ sky130_fd_sc_hd__a31o_1
XFILLER_7_91 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Left_64 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_30_192 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._222_ net55 alu_uart_interfaceUnit._034_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_181 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._153_ aluUnit.i_data_a\[6\] alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._072_
+ net36 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._020_ sky130_fd_sc_hd__o211a_1
XFILLER_44_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._146_ net43 uartUnit.fifoRX._012_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_14_176 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._077_ uartUnit.fifoRX.write_ptr\[0\] uartUnit.fifoRX._045_ uartUnit.fifoRX.write_ptr\[1\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._046_ sky130_fd_sc_hd__and3b_4
XuartUnit.uartTxUnit._143_ uartUnit.fifoTX.o_data_to_read\[4\] uartUnit.uartTxUnit.send_byte\[5\]
+ net14 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._032_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_0_Left_49 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._205_ net54 alu_uart_interfaceUnit._017_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[3\] sky130_fd_sc_hd__dfxtp_1
Xalu_uart_interfaceUnit._136_ alu_uart_interfaceUnit.i_data_to_read\[4\] net20 alu_uart_interfaceUnit._050_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._064_ sky130_fd_sc_hd__or3_1
XFILLER_26_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_246 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_45_9 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_202 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._57_ uartUnit.baud_rateUnit.counter\[7\] uartUnit.baud_rateUnit.counter\[6\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._28_ sky130_fd_sc_hd__nand2_1
XuartUnit.fifoRX._129_ uartUnit.fifoRX.array\[3\]\[3\] uartUnit.fifoRX.i_data_to_write\[3\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._037_ sky130_fd_sc_hd__mux2_1
XFILLER_4_81 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_114 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._126_ uartUnit.uartTxUnit._075_ uartUnit.uartTxUnit._020_ uartUnit.uartTxUnit._076_
+ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._009_ sky130_fd_sc_hd__o211a_1
XuartUnit.fifoTX._080_ uartUnit.fifoTX.array\[2\]\[2\] alu_uart_interfaceUnit.o_data_to_write\[2\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._004_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_271 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_35 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._330_ aluUnit.i_data_b\[7\] aluUnit.i_data_a\[7\] aluUnit._133_ aluUnit._092_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._093_ sky130_fd_sc_hd__a31o_1
XaluUnit._192_ aluUnit.i_op\[3\] aluUnit.i_op\[2\] aluUnit.i_op\[4\] aluUnit.i_op\[5\]
+ vssd1 vssd1 vccd1 vccd1 aluUnit._125_ sky130_fd_sc_hd__or4b_2
XFILLER_14_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._261_ aluUnit._105_ aluUnit._027_ vssd1 vssd1 vccd1 vccd1 aluUnit._028_ sky130_fd_sc_hd__or2_1
Xalu_uart_interfaceUnit._119_ alu_uart_interfaceUnit._090_ alu_uart_interfaceUnit._048_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._054_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_47_341 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_224 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._109_ uartUnit.uartTxUnit._041_ net7 net11 uartUnit.uartTxUnit._063_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._064_ sky130_fd_sc_hd__or4_1
XuartUnit.fifoTX._132_ uartUnit.fifoTX.array\[3\]\[6\] alu_uart_interfaceUnit.o_data_to_write\[6\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._040_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartRxUnit._097_ uartUnit.uartRxUnit._046_ uartUnit.uartRxUnit._047_ uartUnit.uartRxUnit._048_
+ uartUnit.uartRxUnit._027_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._049_ sky130_fd_sc_hd__o31ai_1
XPHY_EDGE_ROW_3_Left_52 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._313_ aluUnit.i_data_b\[6\] aluUnit.i_data_a\[6\] aluUnit._127_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._077_ sky130_fd_sc_hd__a21oi_1
XaluUnit._175_ aluUnit.i_op\[0\] aluUnit.i_op\[1\] aluUnit._107_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._108_ sky130_fd_sc_hd__and3_1
XaluUnit._244_ aluUnit._109_ aluUnit._011_ vssd1 vssd1 vccd1 vccd1 aluUnit._012_ sky130_fd_sc_hd__nand2_1
XFILLER_41_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_10_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_37_132 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Left_94 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_45_44 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_43_146 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_43_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_28_165 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._149_ net43 uartUnit.uartRxUnit._012_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._115_ uartUnit.fifoTX._042_ uartUnit.fifoTX._044_ uartUnit.fifoTX.i_read_fifo
+ uartUnit.fifoTX._043_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._056_ sky130_fd_sc_hd__a31o_1
XFILLER_6_38 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_3_231 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_42_190 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XaluUnit._227_ net30 aluUnit._116_ net25 vssd1 vssd1 vccd1 vccd1 aluUnit._159_ sky130_fd_sc_hd__o21ai_1
XFILLER_25_146 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_40_149 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_40_105 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_31_13 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_48_249 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_0_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_19_Right_19 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._162_ net44 uartUnit.fifoRX._028_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.write_ptr\[0\]
+ sky130_fd_sc_hd__dfxtp_2
XuartUnit.fifoRX._093_ uartUnit.fifoRX.i_data_to_write\[6\] uartUnit.fifoRX.array\[0\]\[6\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._016_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_28_Right_28 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_47_260 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Right_37 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartTxUnit._090_ uartUnit.uartTxUnit.n\[2\] uartUnit.uartTxUnit.n\[1\] uartUnit.uartTxUnit.n\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._050_ sky130_fd_sc_hd__nand3_1
XFILLER_22_138 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_46_Right_46 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._152_ alu_uart_interfaceUnit.i_data_to_read\[6\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._072_ sky130_fd_sc_hd__or2_1
Xalu_uart_interfaceUnit._221_ net55 alu_uart_interfaceUnit._033_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_35 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._145_ net46 uartUnit.fifoRX._011_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_14_177 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Left_81 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_8_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._076_ uartUnit.fifoRX.o_fifo_is_full uartUnit.fifoRX._044_ vssd1
+ vssd1 vccd1 vccd1 uartUnit.fifoRX._045_ sky130_fd_sc_hd__nor2_1
XuartUnit.uartTxUnit._142_ uartUnit.uartTxUnit.send_byte\[3\] net5 uartUnit.uartTxUnit._031_
+ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._014_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_28_247 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._135_ aluUnit.i_op\[3\] alu_uart_interfaceUnit._051_ alu_uart_interfaceUnit._063_
+ net33 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._011_ sky130_fd_sc_hd__o211a_1
Xalu_uart_interfaceUnit._204_ net54 alu_uart_interfaceUnit._016_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_145 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_158 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_9 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.baud_rateUnit._56_ uartUnit.baud_rateUnit.counter\[6\] uartUnit.baud_rateUnit._19_
+ uartUnit.baud_rateUnit._24_ uartUnit.baud_rateUnit.counter\[7\] vssd1 vssd1 vccd1
+ vccd1 uartUnit.baud_rateUnit._27_ sky130_fd_sc_hd__a31o_1
XFILLER_32_222 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._128_ uartUnit.fifoRX.array\[3\]\[2\] uartUnit.fifoRX.i_data_to_write\[2\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._036_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_115 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._125_ net14 uartUnit.uartTxUnit._045_ uartUnit.uartTxUnit._048_
+ uartUnit.uartTxUnit._070_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._020_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_33_272 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_211 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_23_244 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_228 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_11 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._260_ net25 aluUnit._154_ aluUnit._026_ vssd1 vssd1 vccd1 vccd1 aluUnit._027_
+ sky130_fd_sc_hd__a21o_1
XaluUnit._191_ aluUnit.i_op\[1\] aluUnit._122_ aluUnit.i_op\[0\] vssd1 vssd1 vccd1
+ vccd1 aluUnit._124_ sky130_fd_sc_hd__and3b_2
Xalu_uart_interfaceUnit._118_ alu_uart_interfaceUnit.i_fifo_tx_full net35 net12 alu_uart_interfaceUnit._049_
+ alu_uart_interfaceUnit._053_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._004_
+ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_47_342 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._39_ uartUnit.baud_rateUnit.counter\[0\] uartUnit.baud_rateUnit.counter\[1\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._16_ sky130_fd_sc_hd__nand2b_1
XFILLER_9_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_20_269 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_253 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._131_ uartUnit.fifoTX.array\[3\]\[5\] alu_uart_interfaceUnit.o_data_to_write\[5\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._039_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartTxUnit._108_ uartUnit.uartTxUnit.s\[2\] uartUnit.uartTxUnit.s\[1\] uartUnit.uartTxUnit.s\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._063_ sky130_fd_sc_hd__and3_1
XuartUnit.uartRxUnit._096_ uartUnit.uartRxUnit.state\[3\] uartUnit.uartRxUnit.state\[1\]
+ uartUnit.uartRxUnit.state\[2\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._048_
+ sky130_fd_sc_hd__nor3_1
XFILLER_1_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_323 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._243_ net21 aluUnit._010_ net22 vssd1 vssd1 vccd1 vccd1 aluUnit._011_ sky130_fd_sc_hd__or3b_1
XaluUnit._312_ aluUnit.i_data_b\[3\] net22 aluUnit._010_ aluUnit._030_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._076_ sky130_fd_sc_hd__o31a_1
XFILLER_6_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._174_ aluUnit._106_ vssd1 vssd1 vccd1 vccd1 aluUnit._107_ sky130_fd_sc_hd__inv_2
XFILLER_34_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_37_144 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_37_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_20_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_29_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._148_ net43 uartUnit.uartRxUnit._011_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_28_177 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._114_ uartUnit.fifoTX.write_ptr\[1\] uartUnit.fifoTX._054_ uartUnit.fifoTX._055_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._029_ sky130_fd_sc_hd__o21a_1
XuartUnit.uartRxUnit._079_ net9 uartUnit.uartRxUnit._034_ uartUnit.uartRxUnit.state\[3\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._036_ sky130_fd_sc_hd__a21o_1
XFILLER_10_70 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_34_103 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_42_180 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._226_ aluUnit._105_ aluUnit._157_ aluUnit._109_ vssd1 vssd1 vccd1 vccd1 aluUnit._158_
+ sky130_fd_sc_hd__o21a_1
XFILLER_15_26 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_25_158 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_25_169 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._161_ net44 uartUnit.fifoRX._027_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._001_
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_31_139 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._092_ uartUnit.fifoRX.i_data_to_write\[5\] uartUnit.fifoRX.array\[0\]\[5\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._015_ sky130_fd_sc_hd__mux2_1
XFILLER_47_272 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._209_ aluUnit.i_data_a\[1\] aluUnit._139_ vssd1 vssd1 vccd1 vccd1 aluUnit._141_
+ sky130_fd_sc_hd__xor2_1
XFILLER_15_180 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._151_ aluUnit.i_data_a\[5\] alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._071_
+ net35 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._019_ sky130_fd_sc_hd__o211a_1
Xalu_uart_interfaceUnit._220_ net55 alu_uart_interfaceUnit._032_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_143 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_29_272 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoRX._144_ net46 uartUnit.fifoRX._010_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._075_ uartUnit.fifoRX.array\[0\]\[7\] uartUnit.fifoRX.array\[1\]\[7\]
+ uartUnit.fifoRX.array\[2\]\[7\] uartUnit.fifoRX.array\[3\]\[7\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[7\]
+ sky130_fd_sc_hd__mux4_1
XFILLER_8_165 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._141_ net8 net6 uartUnit.uartTxUnit._022_ uartUnit.uartTxUnit._030_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._031_ sky130_fd_sc_hd__or4_1
XFILLER_35_220 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_37_57 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_37_24 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._203_ net54 alu_uart_interfaceUnit._015_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_18_209 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_26_231 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_26_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_41_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_41_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._134_ alu_uart_interfaceUnit.i_data_to_read\[3\] net20 alu_uart_interfaceUnit._050_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._063_ sky130_fd_sc_hd__or3_1
XFILLER_5_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_159 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._55_ uartUnit.baud_rateUnit._09_ uartUnit.baud_rateUnit._25_
+ uartUnit.baud_rateUnit._26_ uartUnit.baud_rateUnit._15_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit._06_ sky130_fd_sc_hd__o211a_1
XFILLER_32_234 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._127_ uartUnit.fifoRX.array\[3\]\[1\] uartUnit.fifoRX.i_data_to_write\[1\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._035_ sky130_fd_sc_hd__mux2_1
XFILLER_4_94 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_116 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._124_ uartUnit.uartTxUnit.n\[1\] uartUnit.uartTxUnit.n\[0\] vssd1
+ vssd1 vccd1 vccd1 uartUnit.uartTxUnit._076_ sky130_fd_sc_hd__or2_1
XFILLER_23_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_229 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_23 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_14_245 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
Xfanout60 net61 vssd1 vssd1 vccd1 vccd1 net60 sky130_fd_sc_hd__clkbuf_2
XFILLER_9_39 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._190_ aluUnit.i_op\[3\] aluUnit.i_op\[4\] aluUnit.i_op\[5\] aluUnit.i_op\[2\]
+ vssd1 vssd1 vccd1 vccd1 aluUnit._123_ sky130_fd_sc_hd__or4bb_2
XFILLER_13_92 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._117_ alu_uart_interfaceUnit.state\[1\] alu_uart_interfaceUnit.state\[0\]
+ alu_uart_interfaceUnit._091_ alu_uart_interfaceUnit._093_ vssd1 vssd1 vccd1 vccd1
+ alu_uart_interfaceUnit._053_ sky130_fd_sc_hd__and4_4
XuartUnit.baud_rateUnit._38_ uartUnit.baud_rateUnit.counter\[0\] net41 vssd1 vssd1
+ vccd1 vccd1 uartUnit.baud_rateUnit._00_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_30_254 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_15 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_18_26 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoTX._130_ uartUnit.fifoTX.array\[3\]\[4\] alu_uart_interfaceUnit.o_data_to_write\[4\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._038_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartTxUnit._107_ net7 net6 uartUnit.uartTxUnit.s\[2\] vssd1 vssd1 vccd1
+ vccd1 uartUnit.uartTxUnit._062_ sky130_fd_sc_hd__o21ai_1
XuartUnit.uartRxUnit._095_ uartUnit.uartRxUnit._029_ uartUnit.uartRxUnit.state\[1\]
+ uartUnit.uartRxUnit.state\[0\] net3 uartUnit.uartRxUnit._040_ vssd1 vssd1 vccd1
+ vccd1 uartUnit.uartRxUnit._047_ sky130_fd_sc_hd__a221o_2
XTAP_TAPCELL_ROW_21_210 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_123 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_324 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._173_ aluUnit.i_op\[3\] aluUnit.i_op\[2\] aluUnit.i_op\[4\] aluUnit.i_op\[5\]
+ vssd1 vssd1 vccd1 vccd1 aluUnit._106_ sky130_fd_sc_hd__or4_1
XaluUnit._242_ net26 aluUnit._102_ aluUnit._104_ aluUnit._155_ vssd1 vssd1 vccd1 vccd1
+ aluUnit._010_ sky130_fd_sc_hd__o31a_1
XaluUnit._311_ aluUnit._040_ aluUnit._047_ aluUnit._056_ aluUnit._058_ aluUnit._072_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._075_ sky130_fd_sc_hd__a311o_1
XFILLER_10_270 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_1_73 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_20_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_29_47 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_29_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_43_159 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartRxUnit._147_ net51 uartUnit.uartRxUnit._010_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.n\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_28_189 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoTX._113_ uartUnit.fifoTX.write_ptr\[1\] uartUnit.fifoTX._054_ net39
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._055_ sky130_fd_sc_hd__a21oi_1
XuartUnit.uartRxUnit._078_ uartUnit.uartRxUnit.s\[3\] uartUnit.uartRxUnit._033_ vssd1
+ vssd1 vccd1 vccd1 uartUnit.uartRxUnit._035_ sky130_fd_sc_hd__nand2_1
XFILLER_3_277 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_10_93 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_34_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_34_115 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_19_91 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._225_ net22 aluUnit._156_ aluUnit._152_ vssd1 vssd1 vccd1 vccd1 aluUnit._157_
+ sky130_fd_sc_hd__a21boi_1
XFILLER_33_181 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_0_225 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._091_ uartUnit.fifoRX.i_data_to_write\[4\] uartUnit.fifoRX.array\[0\]\[4\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._014_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._160_ net44 uartUnit.fifoRX._026_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._000_
+ sky130_fd_sc_hd__dfxtp_4
XFILLER_47_240 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XaluUnit._208_ aluUnit.i_data_a\[1\] aluUnit._139_ vssd1 vssd1 vccd1 vccd1 aluUnit._140_
+ sky130_fd_sc_hd__and2_1
XFILLER_38_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_42_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._150_ alu_uart_interfaceUnit.i_data_to_read\[5\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._071_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_8_144 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_8_122 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._143_ net44 uartUnit.fifoRX._009_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._074_ uartUnit.fifoRX.array\[0\]\[6\] uartUnit.fifoRX.array\[1\]\[6\]
+ uartUnit.fifoRX.array\[2\]\[6\] uartUnit.fifoRX.array\[3\]\[6\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[6\]
+ sky130_fd_sc_hd__mux4_1
XuartUnit.uartTxUnit._140_ uartUnit.fifoTX.o_data_to_read\[3\] uartUnit.uartTxUnit.send_byte\[4\]
+ net14 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._030_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_19_Left_68 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._202_ net54 alu_uart_interfaceUnit._014_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_a\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_243 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_41_279 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._133_ aluUnit.i_op\[2\] alu_uart_interfaceUnit._051_ alu_uart_interfaceUnit._062_
+ net33 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._010_ sky130_fd_sc_hd__o211a_1
XFILLER_5_125 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.baud_rateUnit._54_ uartUnit.baud_rateUnit._19_ uartUnit.baud_rateUnit._24_
+ uartUnit.baud_rateUnit.counter\[6\] vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._26_
+ sky130_fd_sc_hd__a21o_1
XFILLER_32_246 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_17_265 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._126_ uartUnit.fifoRX.array\[3\]\[0\] uartUnit.fifoRX.i_data_to_write\[0\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._034_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartTxUnit._123_ uartUnit.uartTxUnit._054_ uartUnit.uartTxUnit._069_ uartUnit.uartTxUnit._071_
+ uartUnit.uartTxUnit.n\[1\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._075_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_2_117 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_202 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_23_279 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_31_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_48_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._116_ alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._052_
+ alu_uart_interfaceUnit._049_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._003_
+ sky130_fd_sc_hd__o21a_1
Xfanout61 net62 vssd1 vssd1 vccd1 vccd1 net61 sky130_fd_sc_hd__clkbuf_2
Xfanout50 net63 vssd1 vssd1 vccd1 vccd1 net50 sky130_fd_sc_hd__buf_2
XFILLER_22_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_1_150 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.baud_rateUnit._37_ uartUnit.baud_rateUnit._12_ uartUnit.baud_rateUnit._13_
+ uartUnit.baud_rateUnit._14_ uartUnit.baud_rateUnit._11_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit._15_ sky130_fd_sc_hd__o31a_2
XFILLER_9_261 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_20_238 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._109_ uartUnit.fifoRX.read_ptr\[1\] uartUnit.fifoRX._050_ uartUnit.fifoRX._052_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._027_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_30_255 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._106_ uartUnit.uartTxUnit.s\[1\] uartUnit.uartTxUnit.s\[0\] uartUnit.uartTxUnit._060_
+ uartUnit.uartTxUnit._061_ uartUnit.uartTxUnit._043_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._005_
+ sky130_fd_sc_hd__o221a_1
XuartUnit.uartRxUnit._094_ uartUnit.uartRxUnit._029_ uartUnit.uartRxUnit._034_ uartUnit.uartRxUnit.state\[3\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._046_ sky130_fd_sc_hd__o21a_2
XFILLER_34_37 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_11_205 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_211 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._310_ aluUnit._072_ aluUnit._073_ vssd1 vssd1 vccd1 vccd1 aluUnit._074_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_44_325 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._241_ net13 aluUnit._008_ vssd1 vssd1 vccd1 vccd1 aluUnit._009_ sky130_fd_sc_hd__nand2_1
XaluUnit._172_ aluUnit.i_data_b\[3\] aluUnit._104_ vssd1 vssd1 vccd1 vccd1 aluUnit._105_
+ sky130_fd_sc_hd__or2_1
XFILLER_24_92 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_220 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_10_282 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_37_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_29_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._146_ net51 uartUnit.uartRxUnit._009_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.n\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartRxUnit._077_ uartUnit.uartRxUnit.s\[3\] uartUnit.uartRxUnit.s\[2\] uartUnit.uartRxUnit.s\[1\]
+ uartUnit.uartRxUnit.s\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._034_ sky130_fd_sc_hd__and4_2
XuartUnit.fifoTX._112_ net39 uartUnit.fifoTX._053_ uartUnit.fifoTX._054_ vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoTX._028_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_7_Left_56 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_3_245 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_3_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_3_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_10_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_19_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._224_ net25 aluUnit._154_ aluUnit._155_ vssd1 vssd1 vccd1 vccd1 aluUnit._156_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_31_38 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_0_237 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._090_ uartUnit.fifoRX.i_data_to_write\[3\] uartUnit.fifoRX.array\[0\]\[3\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._013_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartRxUnit._129_ uartUnit.fifoRX.i_data_to_write\[5\] uartUnit.uartRxUnit._042_
+ uartUnit.uartRxUnit._057_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._021_ sky130_fd_sc_hd__or3_1
XFILLER_31_119 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_47_252 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_188 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_73 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XaluUnit._207_ net28 aluUnit._138_ vssd1 vssd1 vccd1 vccd1 aluUnit._139_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_Right_15 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_Right_24 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_26_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_21_130 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_145 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_16_71 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_12_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._073_ uartUnit.fifoRX.array\[0\]\[5\] uartUnit.fifoRX.array\[1\]\[5\]
+ uartUnit.fifoRX.array\[2\]\[5\] uartUnit.fifoRX.array\[3\]\[5\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[5\]
+ sky130_fd_sc_hd__mux4_1
XuartUnit.fifoRX._142_ net44 uartUnit.fifoRX._008_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_41_225 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_283 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._132_ alu_uart_interfaceUnit.i_data_to_read\[2\] net20 alu_uart_interfaceUnit._050_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._062_ sky130_fd_sc_hd__or3_1
Xalu_uart_interfaceUnit._201_ net48 alu_uart_interfaceUnit._013_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_op\[5\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_36_Left_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_5_159 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_17_222 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_17_255 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_20_Left_69 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_27_70 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.baud_rateUnit._53_ uartUnit.baud_rateUnit._15_ uartUnit.baud_rateUnit._23_
+ uartUnit.baud_rateUnit._25_ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._05_
+ sky130_fd_sc_hd__and3_1
XuartUnit.fifoRX._125_ uartUnit.fifoRX.write_ptr\[1\] uartUnit.fifoRX.write_ptr\[0\]
+ uartUnit.fifoRX._045_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._064_ sky130_fd_sc_hd__and3_4
XuartUnit.uartTxUnit._122_ uartUnit.uartTxUnit._048_ uartUnit.uartTxUnit._054_ uartUnit.uartTxUnit._069_
+ uartUnit.uartTxUnit._071_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._074_ sky130_fd_sc_hd__nor4_1
XFILLER_48_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xfanout62 net63 vssd1 vssd1 vccd1 vccd1 net62 sky130_fd_sc_hd__clkbuf_2
Xfanout40 net41 vssd1 vssd1 vccd1 vccd1 net40 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout51 net53 vssd1 vssd1 vccd1 vccd1 net51 sky130_fd_sc_hd__clkbuf_2
XFILLER_14_269 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._115_ alu_uart_interfaceUnit.state\[3\] alu_uart_interfaceUnit.wait_reg\[1\]
+ alu_uart_interfaceUnit._045_ alu_uart_interfaceUnit._051_ vssd1 vssd1 vccd1 vccd1
+ alu_uart_interfaceUnit._052_ sky130_fd_sc_hd__a31o_1
XuartUnit.baud_rateUnit._36_ uartUnit.baud_rateUnit._12_ uartUnit.baud_rateUnit._13_
+ uartUnit.baud_rateUnit._14_ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit.o_tick
+ sky130_fd_sc_hd__nor3_1
XFILLER_9_273 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoRX._108_ uartUnit.fifoRX.read_ptr\[1\] uartUnit.fifoRX._050_ net38 vssd1
+ vssd1 vccd1 vccd1 uartUnit.fifoRX._052_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_30_256 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._105_ uartUnit.uartTxUnit.s\[1\] uartUnit.uartTxUnit.s\[0\] uartUnit.uartTxUnit._041_
+ net7 net11 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._061_ sky130_fd_sc_hd__a2111oi_1
XuartUnit.uartRxUnit._093_ net3 uartUnit.uartRxUnit._045_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_write_fifo sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_21_212 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_326 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._240_ net32 net31 aluUnit.i_data_a\[4\] aluUnit.i_data_a\[5\] net30 net25
+ vssd1 vssd1 vccd1 vccd1 aluUnit._008_ sky130_fd_sc_hd__mux4_1
XaluUnit._171_ aluUnit._097_ aluUnit._098_ vssd1 vssd1 vccd1 vccd1 aluUnit._104_ sky130_fd_sc_hd__nor2_1
XFILLER_6_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_232 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_37_103 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_72 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_20_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_29_27 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_43_128 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._111_ uartUnit.fifoTX._043_ uartUnit.fifoTX.i_read_fifo alu_uart_interfaceUnit.o_fifo_tx_write
+ uartUnit.fifoTX.write_ptr\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._054_ sky130_fd_sc_hd__o211a_1
XuartUnit.uartRxUnit._145_ net51 uartUnit.uartRxUnit._008_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.n\[0\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartRxUnit._076_ uartUnit.uartRxUnit.s\[2\] uartUnit.uartRxUnit.s\[1\] uartUnit.uartRxUnit.s\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._033_ sky130_fd_sc_hd__and3_1
XFILLER_3_257 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_103 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_42_161 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_42_150 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._223_ net26 aluUnit._097_ vssd1 vssd1 vccd1 vccd1 aluUnit._155_ sky130_fd_sc_hd__nand2_1
XFILLER_19_169 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_32_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_33_150 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_48_209 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_249 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._128_ uartUnit.fifoRX.i_data_to_write\[3\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._020_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._014_
+ sky130_fd_sc_hd__o211a_1
XFILLER_46_91 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._206_ aluUnit._119_ aluUnit._125_ net29 vssd1 vssd1 vccd1 vccd1 aluUnit._138_
+ sky130_fd_sc_hd__o21a_1
XFILLER_15_194 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_189 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_42_49 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_146 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_153 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoRX._141_ net47 uartUnit.fifoRX._007_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_16_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_8_146 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._072_ uartUnit.fifoRX.array\[0\]\[4\] uartUnit.fifoRX.array\[1\]\[4\]
+ uartUnit.fifoRX.array\[2\]\[4\] uartUnit.fifoRX.array\[3\]\[4\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[4\]
+ sky130_fd_sc_hd__mux4_1
XFILLER_12_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_35_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_170 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_237 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_284 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._131_ aluUnit.i_op\[1\] alu_uart_interfaceUnit._051_ alu_uart_interfaceUnit._061_
+ net33 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._009_ sky130_fd_sc_hd__o211a_1
Xalu_uart_interfaceUnit._200_ net48 alu_uart_interfaceUnit._012_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_op\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_5_105 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.baud_rateUnit._52_ uartUnit.baud_rateUnit._19_ uartUnit.baud_rateUnit._24_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._25_ sky130_fd_sc_hd__nand2_1
XFILLER_17_278 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_240 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_270 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_17_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._124_ uartUnit.fifoRX._061_ uartUnit.fifoRX._063_ net38 vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoRX._033_ sky130_fd_sc_hd__a21o_1
XFILLER_4_182 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._121_ net16 uartUnit.uartTxUnit._072_ uartUnit.uartTxUnit._073_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._008_ sky130_fd_sc_hd__and3_1
Xfanout63 net1 vssd1 vssd1 vccd1 vccd1 net63 sky130_fd_sc_hd__buf_2
Xfanout52 net53 vssd1 vssd1 vccd1 vccd1 net52 sky130_fd_sc_hd__buf_1
Xfanout41 net2 vssd1 vssd1 vccd1 vccd1 net41 sky130_fd_sc_hd__clkbuf_2
Xfanout30 aluUnit.i_data_b\[0\] vssd1 vssd1 vccd1 vccd1 net30 sky130_fd_sc_hd__buf_2
XFILLER_14_237 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._114_ net19 alu_uart_interfaceUnit._050_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._051_ sky130_fd_sc_hd__nor2_2
XFILLER_13_73 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_98 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._35_ uartUnit.baud_rateUnit.counter\[3\] uartUnit.baud_rateUnit.counter\[5\]
+ uartUnit.baud_rateUnit.counter\[4\] uartUnit.baud_rateUnit.counter\[2\] vssd1 vssd1
+ vccd1 vccd1 uartUnit.baud_rateUnit._14_ sky130_fd_sc_hd__or4b_1
XFILLER_13_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoRX._107_ uartUnit.fifoRX.read_ptr\[0\] uartUnit.fifoRX._049_ uartUnit.fifoRX._051_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._026_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_30_257 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._104_ net8 net6 uartUnit.uartTxUnit.s\[1\] vssd1 vssd1 vccd1
+ vccd1 uartUnit.uartTxUnit._060_ sky130_fd_sc_hd__o21a_1
XuartUnit.uartRxUnit._092_ net3 uartUnit.uartRxUnit.state\[0\] uartUnit.uartRxUnit._045_
+ net38 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._000_ sky130_fd_sc_hd__a211o_1
XFILLER_46_115 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_46_148 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_327 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._170_ aluUnit._096_ aluUnit._102_ aluUnit._100_ vssd1 vssd1 vccd1 vccd1 aluUnit._103_
+ sky130_fd_sc_hd__o21bai_1
XFILLER_6_277 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._299_ aluUnit.i_data_b\[5\] aluUnit.i_data_a\[5\] aluUnit._124_ aluUnit._063_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._064_ sky130_fd_sc_hd__o22a_1
XFILLER_29_39 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_45_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._110_ alu_uart_interfaceUnit.o_fifo_tx_write uartUnit.fifoTX.i_read_fifo
+ uartUnit.fifoTX._045_ uartUnit.fifoTX.write_ptr\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._053_
+ sky130_fd_sc_hd__a211oi_1
XFILLER_28_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._144_ net50 uartUnit.uartRxUnit._007_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.s\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_41_308 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._075_ uartUnit.uartRxUnit.s\[1\] uartUnit.uartRxUnit.s\[0\] vssd1
+ vssd1 vccd1 vccd1 uartUnit.uartRxUnit._032_ sky130_fd_sc_hd__and2_1
XFILLER_3_269 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_3_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_10_74 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_10_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._222_ aluUnit._098_ aluUnit._153_ vssd1 vssd1 vccd1 vccd1 aluUnit._154_ sky130_fd_sc_hd__and2_1
XFILLER_25_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_25_129 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_33_162 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_31_18 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._127_ uartUnit.fifoRX.i_data_to_write\[4\] uartUnit.uartRxUnit._042_
+ uartUnit.uartRxUnit._057_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._020_ sky130_fd_sc_hd__or3_1
XFILLER_24_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_21_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_21_95 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_47_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._205_ aluUnit._119_ aluUnit._125_ vssd1 vssd1 vccd1 vccd1 aluUnit._137_ sky130_fd_sc_hd__or2_1
XFILLER_38_243 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_38_287 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Right_5 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_26_29 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_147 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_257 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._071_ uartUnit.fifoRX.array\[0\]\[3\] uartUnit.fifoRX.array\[1\]\[3\]
+ uartUnit.fifoRX.array\[2\]\[3\] uartUnit.fifoRX.array\[3\]\[3\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[3\]
+ sky130_fd_sc_hd__mux4_2
XuartUnit.fifoRX._140_ net42 uartUnit.fifoRX._006_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_12_121 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_12_176 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_171 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_128 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_213 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_41_249 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_41_205 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_285 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._130_ alu_uart_interfaceUnit.i_data_to_read\[1\] net20 alu_uart_interfaceUnit._050_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._061_ sky130_fd_sc_hd__or3_1
XuartUnit.baud_rateUnit._51_ uartUnit.baud_rateUnit.counter\[5\] uartUnit.baud_rateUnit.counter\[4\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._24_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_27_241 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_71 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._123_ uartUnit.fifoRX._058_ uartUnit.fifoRX._062_ net19 vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoRX._063_ sky130_fd_sc_hd__a21o_1
XFILLER_4_194 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartTxUnit._120_ uartUnit.uartTxUnit._054_ uartUnit.uartTxUnit._069_ uartUnit.uartTxUnit._071_
+ uartUnit.uartTxUnit.n\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._073_ sky130_fd_sc_hd__or4b_1
XFILLER_2_109 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_48_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xfanout53 net63 vssd1 vssd1 vccd1 vccd1 net53 sky130_fd_sc_hd__clkbuf_2
Xfanout31 aluUnit.i_data_a\[3\] vssd1 vssd1 vccd1 vccd1 net31 sky130_fd_sc_hd__buf_2
Xfanout42 net45 vssd1 vssd1 vccd1 vccd1 net42 sky130_fd_sc_hd__clkbuf_2
Xalu_uart_interfaceUnit._113_ alu_uart_interfaceUnit.state\[3\] alu_uart_interfaceUnit.state\[2\]
+ alu_uart_interfaceUnit.state\[1\] alu_uart_interfaceUnit.state\[0\] vssd1 vssd1
+ vccd1 vccd1 alu_uart_interfaceUnit._050_ sky130_fd_sc_hd__or4b_4
Xfanout20 alu_uart_interfaceUnit.i_fifo_rx_empty vssd1 vssd1 vccd1 vccd1 net20 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_60 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_99 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_164 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.baud_rateUnit._34_ uartUnit.baud_rateUnit.counter\[1\] uartUnit.baud_rateUnit.counter\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._13_ sky130_fd_sc_hd__nand2b_1
XuartUnit.fifoRX._106_ net38 uartUnit.fifoRX._050_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._051_
+ sky130_fd_sc_hd__nor2_1
XuartUnit.uartTxUnit._103_ uartUnit.uartTxUnit._039_ net7 net6 uartUnit.uartTxUnit._059_
+ uartUnit.uartTxUnit._043_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._004_ sky130_fd_sc_hd__o311a_1
XuartUnit.uartRxUnit._091_ uartUnit.uartRxUnit.state\[3\] net9 uartUnit.uartRxUnit._034_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._045_ sky130_fd_sc_hd__and3_1
XFILLER_40_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_6_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_1_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_45_193 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XaluUnit._298_ aluUnit.i_data_b\[5\] aluUnit.i_data_a\[5\] aluUnit._127_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._063_ sky130_fd_sc_hd__a21oi_1
XFILLER_28_105 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_309 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._143_ net49 uartUnit.uartRxUnit._006_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.s\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_36_160 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartRxUnit._074_ uartUnit.uartRxUnit.state\[2\] vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit._031_ sky130_fd_sc_hd__inv_2
XFILLER_3_215 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_10_20 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_10_53 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._221_ aluUnit.i_data_a\[5\] aluUnit.i_data_a\[6\] net30 vssd1 vssd1 vccd1
+ vccd1 aluUnit._153_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoTX._169_ net58 uartUnit.fifoTX._035_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_18_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._126_ uartUnit.fifoRX.i_data_to_write\[2\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._019_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._013_
+ sky130_fd_sc_hd__o211a_1
XFILLER_24_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_21_30 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_47_211 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_47_233 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_7_32 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._204_ aluUnit._115_ aluUnit._135_ aluUnit._136_ vssd1 vssd1 vccd1 vccd1 aluUnit.o_alu_result\[0\]
+ sky130_fd_sc_hd__or3b_1
XFILLER_30_122 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_7_65 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_38_222 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_42_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_21_166 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_21_188 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_44_247 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.fifoRX._070_ uartUnit.fifoRX.array\[0\]\[2\] uartUnit.fifoRX.array\[1\]\[2\]
+ uartUnit.fifoRX.array\[2\]\[2\] uartUnit.fifoRX.array\[3\]\[2\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[2\]
+ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_11_Right_11 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_16_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartRxUnit._109_ uartUnit.uartRxUnit.state\[3\] uartUnit.uartRxUnit.state\[2\]
+ uartUnit.uartRxUnit.state\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._057_
+ sky130_fd_sc_hd__or3_2
XPHY_EDGE_ROW_20_Right_20 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_35_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_172 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_129 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_41_217 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_286 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._50_ uartUnit.baud_rateUnit.counter\[4\] uartUnit.baud_rateUnit._19_
+ uartUnit.baud_rateUnit.counter\[5\] vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._23_
+ sky130_fd_sc_hd__a21o_1
XFILLER_17_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_27_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_242 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_153 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._189_ net47 alu_uart_interfaceUnit._001_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.wait_reg\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._122_ uartUnit.fifoRX.i_write_fifo uartUnit.fifoRX._059_ alu_uart_interfaceUnit.o_fifo_rx_read
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._062_ sky130_fd_sc_hd__nor3b_1
XFILLER_23_228 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xfanout10 uartUnit.baud_rateUnit.o_tick vssd1 vssd1 vccd1 vccd1 net10 sky130_fd_sc_hd__clkbuf_2
Xfanout21 aluUnit.i_data_b\[3\] vssd1 vssd1 vccd1 vccd1 net21 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_1_110 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._112_ alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._046_
+ alu_uart_interfaceUnit._049_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._002_
+ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_24_223 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout32 aluUnit.i_data_a\[2\] vssd1 vssd1 vccd1 vccd1 net32 sky130_fd_sc_hd__buf_2
XFILLER_13_31 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xfanout43 net45 vssd1 vssd1 vccd1 vccd1 net43 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout54 net55 vssd1 vssd1 vccd1 vccd1 net54 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_121 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_38_72 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.baud_rateUnit._33_ uartUnit.baud_rateUnit.counter\[7\] uartUnit.baud_rateUnit.counter\[6\]
+ uartUnit.baud_rateUnit.counter\[8\] vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._12_
+ sky130_fd_sc_hd__nand3b_1
XFILLER_13_261 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._105_ uartUnit.fifoRX._042_ uartUnit.fifoRX.i_write_fifo alu_uart_interfaceUnit.o_fifo_rx_read
+ uartUnit.fifoRX.read_ptr\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._050_ sky130_fd_sc_hd__o211a_1
XFILLER_48_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.uartTxUnit._102_ uartUnit.uartTxUnit._041_ net7 net11 uartUnit.uartTxUnit._039_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._059_ sky130_fd_sc_hd__o31ai_1
XuartUnit.uartRxUnit._090_ net38 uartUnit.uartRxUnit._044_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit._001_ sky130_fd_sc_hd__nor2_1
XFILLER_24_41 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_24_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_10_231 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_45_183 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XaluUnit._297_ aluUnit._112_ aluUnit._156_ aluUnit._029_ vssd1 vssd1 vccd1 vccd1 aluUnit._062_
+ sky130_fd_sc_hd__a21o_1
XFILLER_28_117 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._142_ net49 uartUnit.uartRxUnit._005_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.s\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_36_194 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartRxUnit._073_ uartUnit.uartRxUnit.state\[1\] vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit._030_ sky130_fd_sc_hd__inv_2
XuartUnit.fifoTX._099_ uartUnit.fifoTX.array\[1\]\[3\] alu_uart_interfaceUnit.o_data_to_write\[3\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._021_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoTX._168_ net57 uartUnit.fifoTX._034_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XaluUnit._220_ aluUnit._096_ net13 aluUnit._150_ aluUnit._151_ vssd1 vssd1 vccd1 vccd1
+ aluUnit._152_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_27_Left_76 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_18_183 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._125_ uartUnit.fifoRX.i_data_to_write\[3\] uartUnit.uartRxUnit._042_
+ uartUnit.uartRxUnit._057_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._019_ sky130_fd_sc_hd__or3_1
XFILLER_24_131 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_24_153 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_24_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_47_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XaluUnit._203_ net23 aluUnit._118_ aluUnit._121_ aluUnit._113_ vssd1 vssd1 vccd1 vccd1
+ aluUnit._136_ sky130_fd_sc_hd__a211o_1
XFILLER_15_142 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_15_175 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_7_44 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_7_11 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_30_145 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_30_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_29_212 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._108_ uartUnit.uartRxUnit.s\[3\] uartUnit.uartRxUnit._054_ uartUnit.uartRxUnit._056_
+ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._007_ sky130_fd_sc_hd__o211a_1
XFILLER_32_96 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_12_134 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_43_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_35_248 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_63 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_287 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_240 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._188_ net47 alu_uart_interfaceUnit._000_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.wait_reg\[0\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._121_ uartUnit.fifoRX.o_fifo_is_full uartUnit.fifoRX._044_ alu_uart_interfaceUnit.o_fifo_rx_read
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._061_ sky130_fd_sc_hd__or3_1
XFILLER_25_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_4_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_154 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_45 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_268 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_111 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout22 net23 vssd1 vssd1 vccd1 vccd1 net22 sky130_fd_sc_hd__buf_2
Xfanout33 net36 vssd1 vssd1 vccd1 vccd1 net33 sky130_fd_sc_hd__clkbuf_2
XFILLER_14_229 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xfanout44 net45 vssd1 vssd1 vccd1 vccd1 net44 sky130_fd_sc_hd__clkbuf_2
XFILLER_22_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xfanout55 net63 vssd1 vssd1 vccd1 vccd1 net55 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_24_224 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._111_ net39 alu_uart_interfaceUnit._048_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._049_ sky130_fd_sc_hd__nor2_1
XFILLER_13_43 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_22_262 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_8_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_1_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_1_188 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_338 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._32_ net41 vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._11_
+ sky130_fd_sc_hd__inv_2
XuartUnit.fifoRX._104_ uartUnit.fifoRX._042_ uartUnit.fifoRX.i_write_fifo alu_uart_interfaceUnit.o_fifo_rx_read
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._049_ sky130_fd_sc_hd__o21a_1
XFILLER_48_181 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._101_ net9 uartUnit.uartTxUnit._057_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit._058_ sky130_fd_sc_hd__nor2_1
XFILLER_40_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_40_63 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_40_41 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_6_236 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_45_151 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._296_ aluUnit._126_ aluUnit._060_ vssd1 vssd1 vccd1 vccd1 aluUnit._061_ sky130_fd_sc_hd__nand2_1
Xinput1 i_clk vssd1 vssd1 vccd1 vccd1 net1 sky130_fd_sc_hd__clkbuf_1
XuartUnit.uartRxUnit._141_ net49 uartUnit.uartRxUnit._004_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.s\[0\] sky130_fd_sc_hd__dfxtp_2
XFILLER_28_129 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartRxUnit._072_ net9 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._029_
+ sky130_fd_sc_hd__inv_2
XFILLER_19_129 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_35_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_35_63 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_42_165 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._167_ net53 uartUnit.fifoTX._033_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_fifo_is_empty
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_2_Left_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._098_ uartUnit.fifoTX.array\[1\]\[2\] alu_uart_interfaceUnit.o_data_to_write\[2\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._020_ sky130_fd_sc_hd__mux2_1
XFILLER_33_121 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_18_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._279_ aluUnit._004_ aluUnit._005_ aluUnit._024_ aluUnit._044_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._045_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_209 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._124_ uartUnit.fifoRX.i_data_to_write\[1\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._067_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._012_
+ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_44_Left_93 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_24_165 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._202_ aluUnit.i_data_a\[0\] net29 aluUnit._133_ aluUnit._132_ aluUnit._130_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._135_ sky130_fd_sc_hd__a311o_1
XFILLER_15_121 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_15_154 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_23_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_46_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_21_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_37_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_16_21 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.uartRxUnit._107_ uartUnit.uartRxUnit._035_ uartUnit.uartRxUnit._055_ uartUnit.uartRxUnit._047_
+ uartUnit.uartRxUnit._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._056_ sky130_fd_sc_hd__a211o_1
XFILLER_28_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_7_161 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_9_Right_9 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._120_ uartUnit.fifoRX._056_ uartUnit.fifoRX._060_ net38 vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoRX._032_ sky130_fd_sc_hd__a21oi_1
Xalu_uart_interfaceUnit._187_ net36 alu_uart_interfaceUnit._089_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._037_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_10_155 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_4_57 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_31_Left_80 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_269 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_112 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout56 net62 vssd1 vssd1 vccd1 vccd1 net56 sky130_fd_sc_hd__clkbuf_2
Xfanout34 net36 vssd1 vssd1 vccd1 vccd1 net34 sky130_fd_sc_hd__buf_1
Xfanout23 net24 vssd1 vssd1 vccd1 vccd1 net23 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_11 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xfanout45 net63 vssd1 vssd1 vccd1 vccd1 net45 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_24_225 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._110_ net19 alu_uart_interfaceUnit._045_ net12 alu_uart_interfaceUnit.i_fifo_tx_full
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._048_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_47_339 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.baud_rateUnit._31_ uartUnit.baud_rateUnit.counter\[8\] vssd1 vssd1 vccd1
+ vccd1 uartUnit.baud_rateUnit._10_ sky130_fd_sc_hd__inv_2
XFILLER_9_212 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_9_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._103_ uartUnit.fifoRX.array\[1\]\[7\] uartUnit.fifoRX.i_data_to_write\[7\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._025_ sky130_fd_sc_hd__mux2_1
XFILLER_48_193 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartTxUnit._100_ uartUnit.uartTxUnit.state\[2\] net14 uartUnit.uartTxUnit.state\[3\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._057_ sky130_fd_sc_hd__nor3_1
XFILLER_24_54 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_40_97 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_40_75 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_37_119 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_320 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._295_ aluUnit._040_ aluUnit._047_ aluUnit._057_ aluUnit._058_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._060_ sky130_fd_sc_hd__a211o_1
XFILLER_5_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
Xinput2 i_reset vssd1 vssd1 vccd1 vccd1 net2 sky130_fd_sc_hd__clkbuf_1
XuartUnit.uartRxUnit._140_ net50 uartUnit.uartRxUnit._003_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.state\[3\] sky130_fd_sc_hd__dfxtp_2
XuartUnit.uartRxUnit._071_ net38 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._028_
+ sky130_fd_sc_hd__inv_2
XFILLER_35_97 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_27_163 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_27_185 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._166_ net53 uartUnit.fifoTX._032_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_fifo_tx_full
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._097_ uartUnit.fifoTX.array\[1\]\[1\] alu_uart_interfaceUnit.o_data_to_write\[1\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._019_ sky130_fd_sc_hd__mux2_1
XFILLER_2_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_33_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_18_130 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._278_ net31 aluUnit._022_ aluUnit._043_ vssd1 vssd1 vccd1 vccd1 aluUnit._044_
+ sky130_fd_sc_hd__o21ai_1
XuartUnit.uartRxUnit._123_ uartUnit.fifoRX.i_data_to_write\[2\] uartUnit.uartRxUnit._042_
+ uartUnit.uartRxUnit._057_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._067_ sky130_fd_sc_hd__or3_1
XFILLER_24_177 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_21_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_46_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoTX._149_ net58 uartUnit.fifoTX._015_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XaluUnit._201_ net23 aluUnit._121_ vssd1 vssd1 vccd1 vccd1 aluUnit._134_ sky130_fd_sc_hd__or2_1
XFILLER_15_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_15_166 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_16_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_38_269 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_183 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.uartRxUnit._106_ uartUnit.uartRxUnit.state\[2\] uartUnit.uartRxUnit._039_
+ uartUnit.uartRxUnit.state\[3\] uartUnit.uartRxUnit.state\[1\] vssd1 vssd1 vccd1
+ vccd1 uartUnit.uartRxUnit._055_ sky130_fd_sc_hd__a211o_1
XFILLER_12_125 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_32_65 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_140 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_250 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_40_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._186_ alu_uart_interfaceUnit.o_data_to_write\[7\] aluUnit.o_alu_result\[7\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._089_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_156 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_14_209 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xfanout57 net62 vssd1 vssd1 vccd1 vccd1 net57 sky130_fd_sc_hd__clkbuf_2
Xfanout24 aluUnit.i_data_b\[2\] vssd1 vssd1 vccd1 vccd1 net24 sky130_fd_sc_hd__clkbuf_2
Xfanout46 net48 vssd1 vssd1 vccd1 vccd1 net46 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_23 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_22_286 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_226 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout35 net36 vssd1 vssd1 vccd1 vccd1 net35 sky130_fd_sc_hd__buf_2
XFILLER_1_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.baud_rateUnit._30_ uartUnit.baud_rateUnit.counter\[6\] vssd1 vssd1 vccd1
+ vccd1 uartUnit.baud_rateUnit._09_ sky130_fd_sc_hd__inv_2
XFILLER_9_279 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._102_ uartUnit.fifoRX.array\[1\]\[6\] uartUnit.fifoRX.i_data_to_write\[6\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._024_ sky130_fd_sc_hd__mux2_1
Xalu_uart_interfaceUnit._169_ net35 alu_uart_interfaceUnit._080_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._028_ sky130_fd_sc_hd__and2_1
XuartUnit.uartTxUnit._159_ net62 uartUnit.uartTxUnit._004_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.s\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_66 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_1_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_321 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._294_ aluUnit._057_ aluUnit._058_ aluUnit._040_ aluUnit._047_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._059_ sky130_fd_sc_hd__o211a_1
XFILLER_46_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_Right_18 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._070_ uartUnit.uartRxUnit.s\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._027_
+ sky130_fd_sc_hd__inv_2
XFILLER_36_186 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Right_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xinput3 i_uartRx vssd1 vssd1 vccd1 vccd1 net3 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_36_Right_36 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_10_46 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_10_79 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_19_11 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_19_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Right_45 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._165_ net51 uartUnit.fifoTX._031_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.read_ptr\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._096_ uartUnit.fifoTX.array\[1\]\[0\] alu_uart_interfaceUnit.o_data_to_write\[0\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._018_ sky130_fd_sc_hd__mux2_1
XFILLER_18_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._277_ net32 aluUnit._001_ aluUnit._022_ net31 vssd1 vssd1 vccd1 vccd1 aluUnit._043_
+ sky130_fd_sc_hd__a22o_1
XuartUnit.uartRxUnit._122_ uartUnit.fifoRX.i_data_to_write\[0\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._066_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._011_
+ sky130_fd_sc_hd__o211a_1
XFILLER_24_189 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoTX._148_ net60 uartUnit.fifoTX._014_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XaluUnit._200_ aluUnit.i_op\[0\] aluUnit.i_op\[1\] aluUnit._123_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._133_ sky130_fd_sc_hd__nor3_4
XuartUnit.fifoTX._079_ uartUnit.fifoTX.array\[2\]\[1\] alu_uart_interfaceUnit.o_data_to_write\[1\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._003_ sky130_fd_sc_hd__mux2_1
XFILLER_30_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_38_226 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_184 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._329_ aluUnit._127_ aluUnit._085_ vssd1 vssd1 vccd1 vccd1 aluUnit._092_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_39_298 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_259 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.uartRxUnit._105_ uartUnit.uartRxUnit._046_ uartUnit.uartRxUnit._047_ uartUnit.uartRxUnit._033_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._054_ sky130_fd_sc_hd__nor3b_1
XPHY_EDGE_ROW_0_Right_0 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_32_88 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_141 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_229 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_7_185 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_27_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_157 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._185_ net36 alu_uart_interfaceUnit._088_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._036_ sky130_fd_sc_hd__and2_1
XFILLER_4_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_16_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_Left_67 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xfanout14 uartUnit.uartTxUnit.state\[1\] vssd1 vssd1 vccd1 vccd1 net14 sky130_fd_sc_hd__buf_2
Xfanout58 net61 vssd1 vssd1 vccd1 vccd1 net58 sky130_fd_sc_hd__clkbuf_2
Xfanout25 net27 vssd1 vssd1 vccd1 vccd1 net25 sky130_fd_sc_hd__buf_2
Xfanout47 net48 vssd1 vssd1 vccd1 vccd1 net47 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_24_227 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout36 net37 vssd1 vssd1 vccd1 vccd1 net36 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_158 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_1_169 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_9_225 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_13_232 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._101_ uartUnit.fifoRX.array\[1\]\[5\] uartUnit.fifoRX.i_data_to_write\[5\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._023_ sky130_fd_sc_hd__mux2_1
Xalu_uart_interfaceUnit._168_ aluUnit.i_data_b\[6\] alu_uart_interfaceUnit.i_data_to_read\[6\]
+ alu_uart_interfaceUnit._053_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._080_
+ sky130_fd_sc_hd__mux2_1
Xalu_uart_interfaceUnit._099_ alu_uart_interfaceUnit.state\[1\] net19 alu_uart_interfaceUnit._093_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._039_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_21_208 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_140 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._158_ net52 uartUnit.uartTxUnit._003_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.state\[3\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._089_ uartUnit.uartTxUnit.n\[2\] uartUnit.uartTxUnit.n\[1\] uartUnit.uartTxUnit.n\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._049_ sky130_fd_sc_hd__and3_1
XFILLER_24_78 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_6_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_45_143 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_45_121 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_1_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_1_49 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_322 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._293_ aluUnit.i_data_a\[5\] aluUnit._055_ vssd1 vssd1 vccd1 vccd1 aluUnit._058_
+ sky130_fd_sc_hd__nor2_1
XFILLER_39_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_19_23 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_67 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_27_110 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_303 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._164_ net51 uartUnit.fifoTX._030_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.read_ptr\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._095_ uartUnit.fifoTX.write_ptr\[1\] uartUnit.fifoTX.write_ptr\[0\]
+ uartUnit.fifoTX._045_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._048_ sky130_fd_sc_hd__and3b_4
XFILLER_2_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_33_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._276_ aluUnit._040_ aluUnit._041_ vssd1 vssd1 vccd1 vccd1 aluUnit._042_ sky130_fd_sc_hd__and2_1
XuartUnit.uartRxUnit._121_ uartUnit.fifoRX.i_data_to_write\[1\] uartUnit.uartRxUnit._042_
+ uartUnit.uartRxUnit._057_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._066_ sky130_fd_sc_hd__or3_1
XFILLER_32_190 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_24_135 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_21_57 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_46_76 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
Xmax_cap11 uartUnit.uartTxUnit._057_ vssd1 vssd1 vccd1 vccd1 net11 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_6_Left_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_15_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._147_ net59 uartUnit.fifoTX._013_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._078_ uartUnit.fifoTX.array\[2\]\[0\] alu_uart_interfaceUnit.o_data_to_write\[0\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._002_ sky130_fd_sc_hd__mux2_1
XFILLER_30_105 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_30_149 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._328_ aluUnit._131_ aluUnit._083_ aluUnit._090_ vssd1 vssd1 vccd1 vccd1 aluUnit._091_
+ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_16_185 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._259_ aluUnit._096_ net13 aluUnit._149_ net22 vssd1 vssd1 vccd1 vccd1 aluUnit._026_
+ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_48_Left_97 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_299 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._104_ uartUnit.uartRxUnit.s\[2\] uartUnit.uartRxUnit._032_ uartUnit.uartRxUnit._052_
+ uartUnit.uartRxUnit._053_ net18 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._006_
+ sky130_fd_sc_hd__o221a_1
XFILLER_35_208 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_142 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_21_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_8_91 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_123 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_11 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_280 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._184_ alu_uart_interfaceUnit.o_data_to_write\[6\] aluUnit.o_alu_result\[6\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._088_
+ sky130_fd_sc_hd__mux2_1
XFILLER_4_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_31_277 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xfanout15 uartUnit.uartTxUnit.state\[1\] vssd1 vssd1 vccd1 vccd1 net15 sky130_fd_sc_hd__clkbuf_2
XuartUnit.uartTxUnit._174_ net52 uartUnit.uartTxUnit._019_ vssd1 vssd1 vccd1 vccd1
+ net4 sky130_fd_sc_hd__dfxtp_1
Xfanout26 net27 vssd1 vssd1 vccd1 vccd1 net26 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_22_200 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
Xfanout37 alu_uart_interfaceUnit._092_ vssd1 vssd1 vccd1 vccd1 net37 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout59 net61 vssd1 vssd1 vccd1 vccd1 net59 sky130_fd_sc_hd__buf_1
Xfanout48 net63 vssd1 vssd1 vccd1 vccd1 net48 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_35_Left_84 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_9_237 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._100_ uartUnit.fifoRX.array\[1\]\[4\] uartUnit.fifoRX.i_data_to_write\[4\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._022_ sky130_fd_sc_hd__mux2_1
XFILLER_13_222 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_13_244 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._167_ net35 alu_uart_interfaceUnit._079_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._027_ sky130_fd_sc_hd__and2_1
Xalu_uart_interfaceUnit._098_ alu_uart_interfaceUnit.state\[3\] alu_uart_interfaceUnit.state\[2\]
+ alu_uart_interfaceUnit.state\[0\] alu_uart_interfaceUnit.state\[1\] vssd1 vssd1
+ vccd1 vccd1 alu_uart_interfaceUnit._038_ sky130_fd_sc_hd__or4b_2
XFILLER_48_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_0_181 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_209 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_81 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_39_152 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._088_ uartUnit.uartTxUnit.n\[1\] uartUnit.uartTxUnit.n\[0\] vssd1
+ vssd1 vccd1 vccd1 uartUnit.uartTxUnit._048_ sky130_fd_sc_hd__nand2_1
XuartUnit.uartTxUnit._157_ net52 uartUnit.uartTxUnit._002_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.state\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_45_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._292_ aluUnit._056_ vssd1 vssd1 vccd1 vccd1 aluUnit._057_ sky130_fd_sc_hd__inv_2
Xalu_uart_interfaceUnit._219_ net55 alu_uart_interfaceUnit._031_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_19_35 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_57 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._163_ net57 uartUnit.fifoTX._029_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.write_ptr\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_42_169 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_304 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._094_ alu_uart_interfaceUnit.o_data_to_write\[7\] uartUnit.fifoTX.array\[0\]\[7\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._017_ sky130_fd_sc_hd__mux2_1
XFILLER_2_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_33_169 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_18_177 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._275_ aluUnit.i_data_a\[4\] aluUnit._039_ vssd1 vssd1 vccd1 vccd1 aluUnit._041_
+ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_22_Left_71 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._120_ uartUnit.uartRxUnit._042_ uartUnit.uartRxUnit._057_ vssd1
+ vssd1 vccd1 vccd1 uartUnit.uartRxUnit._065_ sky130_fd_sc_hd__nor2_2
XFILLER_24_125 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xmax_cap12 alu_uart_interfaceUnit._047_ vssd1 vssd1 vccd1 vccd1 net12 sky130_fd_sc_hd__buf_1
XFILLER_46_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_15_169 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoTX._146_ net58 uartUnit.fifoTX._012_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._077_ uartUnit.fifoTX.write_ptr\[0\] uartUnit.fifoTX._045_ uartUnit.fifoTX.write_ptr\[1\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._046_ sky130_fd_sc_hd__and3b_4
XaluUnit._258_ aluUnit._020_ aluUnit._023_ vssd1 vssd1 vccd1 vccd1 aluUnit._025_ sky130_fd_sc_hd__xnor2_1
XaluUnit._327_ aluUnit.i_data_a\[7\] aluUnit._108_ aluUnit._124_ aluUnit._083_ vssd1
+ vssd1 vccd1 vccd1 aluUnit._090_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_16_186 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._189_ aluUnit.i_op\[3\] aluUnit.i_op\[4\] aluUnit.i_op\[5\] aluUnit.i_op\[2\]
+ vssd1 vssd1 vccd1 vccd1 aluUnit._122_ sky130_fd_sc_hd__and4bb_1
XFILLER_44_209 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._103_ uartUnit.uartRxUnit._033_ uartUnit.uartRxUnit._046_ uartUnit.uartRxUnit._047_
+ uartUnit.uartRxUnit._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._053_ sky130_fd_sc_hd__nor4_1
XFILLER_20_161 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._129_ uartUnit.fifoTX.array\[3\]\[3\] alu_uart_interfaceUnit.o_data_to_write\[3\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._037_ sky130_fd_sc_hd__mux2_1
XFILLER_7_110 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_14_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_261 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_124 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_35 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_43_45 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_281 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._183_ net37 alu_uart_interfaceUnit._087_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._035_ sky130_fd_sc_hd__and2_1
XFILLER_40_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_16_231 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_16_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit._0_ uartUnit.fifoTX.o_fifo_is_empty vssd1 vssd1 vccd1 vccd1 uartUnit.tx_not_empty
+ sky130_fd_sc_hd__inv_2
Xfanout49 net50 vssd1 vssd1 vccd1 vccd1 net49 sky130_fd_sc_hd__clkbuf_2
XuartUnit.uartTxUnit._173_ net60 uartUnit.uartTxUnit._018_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[7\] sky130_fd_sc_hd__dfxtp_1
Xfanout16 uartUnit.uartTxUnit._043_ vssd1 vssd1 vccd1 vccd1 net16 sky130_fd_sc_hd__buf_2
Xfanout27 net28 vssd1 vssd1 vccd1 vccd1 net27 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_22_234 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xfanout38 net41 vssd1 vssd1 vccd1 vccd1 net38 sky130_fd_sc_hd__buf_2
XFILLER_1_138 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_9_249 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_13_256 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_13_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._166_ aluUnit.i_data_b\[5\] alu_uart_interfaceUnit.i_data_to_read\[5\]
+ alu_uart_interfaceUnit._053_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._079_
+ sky130_fd_sc_hd__mux2_1
Xalu_uart_interfaceUnit._097_ alu_uart_interfaceUnit.state\[3\] alu_uart_interfaceUnit.state\[2\]
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._093_ sky130_fd_sc_hd__nor2_1
XFILLER_0_193 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_48_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._159_ net44 uartUnit.fifoRX._025_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_5_93 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_39_186 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_39_164 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.uartTxUnit._156_ net52 uartUnit.uartTxUnit._001_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.state\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._087_ net39 net7 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._000_
+ sky130_fd_sc_hd__or2_1
XaluUnit._291_ aluUnit.i_data_a\[5\] aluUnit._055_ vssd1 vssd1 vccd1 vccd1 aluUnit._056_
+ sky130_fd_sc_hd__nand2_1
Xalu_uart_interfaceUnit._218_ net57 alu_uart_interfaceUnit._030_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_data_to_write\[0\] sky130_fd_sc_hd__dfxtp_1
Xalu_uart_interfaceUnit._149_ aluUnit.i_data_a\[4\] alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._070_
+ net33 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._018_ sky130_fd_sc_hd__o211a_1
XFILLER_10_38 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_19_47 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_35_24 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._162_ net57 uartUnit.fifoTX._028_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.write_ptr\[0\]
+ sky130_fd_sc_hd__dfxtp_2
XuartUnit.uartTxUnit._139_ uartUnit.uartTxUnit.send_byte\[2\] net5 uartUnit.uartTxUnit._029_
+ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._013_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_40_305 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._093_ alu_uart_interfaceUnit.o_data_to_write\[6\] uartUnit.fifoTX.array\[0\]\[6\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._016_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_14_Right_14 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_2_277 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_2_222 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Right_23 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_18_134 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_41_181 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_33_126 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._274_ aluUnit.i_data_a\[4\] aluUnit._039_ vssd1 vssd1 vccd1 vccd1 aluUnit._040_
+ sky130_fd_sc_hd__nand2_1
XFILLER_44_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Right_41 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xmax_cap13 aluUnit._098_ vssd1 vssd1 vccd1 vccd1 net13 sky130_fd_sc_hd__clkbuf_2
XuartUnit.fifoTX._145_ net58 uartUnit.fifoTX._011_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_30_129 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoTX._076_ alu_uart_interfaceUnit.i_fifo_tx_full uartUnit.fifoTX._044_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._045_ sky130_fd_sc_hd__nor2_1
XFILLER_11_81 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._257_ aluUnit._023_ vssd1 vssd1 vccd1 vccd1 aluUnit._024_ sky130_fd_sc_hd__inv_2
XaluUnit._188_ net21 aluUnit._106_ aluUnit._119_ vssd1 vssd1 vccd1 vccd1 aluUnit._121_
+ sky130_fd_sc_hd__or3_1
XFILLER_14_192 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_187 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._326_ aluUnit._070_ aluUnit._075_ aluUnit._087_ vssd1 vssd1 vccd1 vccd1 aluUnit._089_
+ sky130_fd_sc_hd__a21bo_1
XuartUnit.uartRxUnit._102_ uartUnit.uartRxUnit._046_ uartUnit.uartRxUnit._047_ uartUnit.uartRxUnit.s\[2\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._052_ sky130_fd_sc_hd__o21a_1
XFILLER_20_173 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_20_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_32_36 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_43_243 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_28_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_28_262 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_43_276 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_11_140 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_168 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._128_ uartUnit.fifoTX.array\[3\]\[2\] alu_uart_interfaceUnit.o_data_to_write\[2\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._036_ sky130_fd_sc_hd__mux2_1
XFILLER_7_177 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_19_273 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XaluUnit._309_ aluUnit._040_ aluUnit._047_ aluUnit._056_ aluUnit._058_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._073_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_4_Right_4 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_125 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_238 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_282 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._182_ alu_uart_interfaceUnit.o_data_to_write\[5\] aluUnit.o_alu_result\[5\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._087_
+ sky130_fd_sc_hd__mux2_1
XFILLER_25_243 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_16_287 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.fifoRX._175_ net44 uartUnit.fifoRX._041_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_31_257 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xfanout39 net41 vssd1 vssd1 vccd1 vccd1 net39 sky130_fd_sc_hd__clkbuf_4
XuartUnit.uartTxUnit._172_ net60 uartUnit.uartTxUnit._017_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[6\] sky130_fd_sc_hd__dfxtp_1
Xfanout17 uartUnit.uartRxUnit._028_ vssd1 vssd1 vccd1 vccd1 net17 sky130_fd_sc_hd__buf_2
Xfanout28 aluUnit.i_data_b\[1\] vssd1 vssd1 vccd1 vccd1 net28 sky130_fd_sc_hd__clkbuf_2
XFILLER_22_268 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_263 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._165_ net35 alu_uart_interfaceUnit._078_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._026_ sky130_fd_sc_hd__and2_1
XFILLER_21_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._096_ net39 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._092_
+ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_46_333 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._089_ uartUnit.fifoRX.i_data_to_write\[2\] uartUnit.fifoRX.array\[0\]\[2\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._012_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._158_ net47 uartUnit.fifoRX._024_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_24_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._155_ net52 uartUnit.uartTxUnit._000_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.state\[0\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._086_ net10 uartUnit.uartTxUnit.state\[3\] uartUnit.uartTxUnit._044_
+ uartUnit.uartTxUnit._042_ uartUnit.uartTxUnit.state\[0\] vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit._047_ sky130_fd_sc_hd__a32o_1
XFILLER_10_205 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_10_249 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._148_ alu_uart_interfaceUnit.i_data_to_read\[4\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._070_ sky130_fd_sc_hd__or2_1
Xalu_uart_interfaceUnit._217_ net55 alu_uart_interfaceUnit._029_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[7\] sky130_fd_sc_hd__dfxtp_1
XaluUnit._290_ aluUnit.i_data_b\[5\] aluUnit._054_ vssd1 vssd1 vccd1 vccd1 aluUnit._055_
+ sky130_fd_sc_hd__xnor2_1
XuartUnit.baud_rateUnit._69_ net49 uartUnit.baud_rateUnit._08_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[8\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._138_ net8 uartUnit.uartTxUnit._058_ uartUnit.uartTxUnit._022_
+ uartUnit.uartTxUnit._028_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._029_ sky130_fd_sc_hd__or4_1
XFILLER_42_127 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_42_116 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_306 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._092_ alu_uart_interfaceUnit.o_data_to_write\[5\] uartUnit.fifoTX.array\[0\]\[5\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._015_ sky130_fd_sc_hd__mux2_1
XFILLER_35_190 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoTX._161_ net51 uartUnit.fifoTX._027_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._001_
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_35_36 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_4_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_2_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_18_157 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_41_193 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_33_138 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._273_ aluUnit.i_data_b\[4\] aluUnit._038_ vssd1 vssd1 vccd1 vccd1 aluUnit._039_
+ sky130_fd_sc_hd__xor2_1
XFILLER_25_80 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_37_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_2_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_21_38 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._075_ uartUnit.fifoTX.array\[0\]\[7\] uartUnit.fifoTX.array\[1\]\[7\]
+ uartUnit.fifoTX.array\[2\]\[7\] uartUnit.fifoTX.array\[3\]\[7\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[7\]
+ sky130_fd_sc_hd__mux4_1
XuartUnit.fifoTX._144_ net57 uartUnit.fifoTX._010_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[0\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_11_93 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._325_ aluUnit._087_ aluUnit._075_ aluUnit._070_ vssd1 vssd1 vccd1 vccd1 aluUnit._088_
+ sky130_fd_sc_hd__nand3b_1
XaluUnit._256_ net31 aluUnit._022_ vssd1 vssd1 vccd1 vccd1 aluUnit._023_ sky130_fd_sc_hd__xor2_1
XaluUnit._187_ net21 aluUnit._106_ aluUnit._119_ vssd1 vssd1 vccd1 vccd1 aluUnit._120_
+ sky130_fd_sc_hd__nor3_1
XFILLER_14_182 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_37_252 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.uartRxUnit._101_ uartUnit.uartRxUnit.s\[1\] uartUnit.uartRxUnit.s\[0\] uartUnit.uartRxUnit._050_
+ uartUnit.uartRxUnit._051_ net18 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._005_
+ sky130_fd_sc_hd__o221a_1
XFILLER_16_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_20_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_32_26 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_32_48 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_11_152 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_11_185 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_169 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._127_ uartUnit.fifoTX.array\[3\]\[1\] alu_uart_interfaceUnit.o_data_to_write\[1\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._035_ sky130_fd_sc_hd__mux2_1
XFILLER_7_167 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._308_ aluUnit._070_ aluUnit._071_ vssd1 vssd1 vccd1 vccd1 aluUnit._072_ sky130_fd_sc_hd__nand2_1
XaluUnit._239_ aluUnit._004_ aluUnit._005_ aluUnit._126_ vssd1 vssd1 vccd1 vccd1 aluUnit._007_
+ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_4_126 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._181_ net37 alu_uart_interfaceUnit._086_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._034_ sky130_fd_sc_hd__and2_1
XFILLER_25_255 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_239 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_148 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_4_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_16_244 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_31_225 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._174_ net44 uartUnit.fifoRX._040_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_31_269 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._171_ net61 uartUnit.uartTxUnit._016_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[5\] sky130_fd_sc_hd__dfxtp_1
Xfanout18 uartUnit.uartRxUnit._028_ vssd1 vssd1 vccd1 vccd1 net18 sky130_fd_sc_hd__buf_1
Xfanout29 aluUnit.i_data_b\[0\] vssd1 vssd1 vccd1 vccd1 net29 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_32_264 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_107 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._164_ aluUnit.i_data_b\[4\] alu_uart_interfaceUnit.i_data_to_read\[4\]
+ alu_uart_interfaceUnit._053_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._078_
+ sky130_fd_sc_hd__mux2_1
XFILLER_13_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_220 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._095_ net19 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._091_
+ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_46_334 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._157_ net47 uartUnit.fifoRX._023_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._088_ uartUnit.fifoRX.i_data_to_write\[1\] uartUnit.fifoRX.array\[0\]\[1\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._011_ sky130_fd_sc_hd__mux2_1
XFILLER_8_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._154_ uartUnit.uartTxUnit.send_byte\[0\] net14 net40 uartUnit.uartTxUnit._071_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._019_ sky130_fd_sc_hd__a211o_1
XFILLER_24_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._085_ net10 uartUnit.uartTxUnit.state\[3\] uartUnit.uartTxUnit._044_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.i_read_fifo sky130_fd_sc_hd__and3_2
XFILLER_40_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_10_239 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_39_Left_88 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._147_ net31 alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._069_
+ net34 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._017_ sky130_fd_sc_hd__o211a_1
Xalu_uart_interfaceUnit._216_ net55 alu_uart_interfaceUnit._028_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_30_81 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.baud_rateUnit._68_ net49 uartUnit.baud_rateUnit._07_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_15 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._137_ uartUnit.fifoTX.o_data_to_read\[2\] uartUnit.uartTxUnit.send_byte\[3\]
+ net15 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._028_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoTX._091_ alu_uart_interfaceUnit.o_data_to_write\[4\] uartUnit.fifoTX.array\[0\]\[4\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._014_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_40_307 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._160_ net51 uartUnit.fifoTX._026_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._000_
+ sky130_fd_sc_hd__dfxtp_4
XFILLER_18_169 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._272_ aluUnit._137_ aluUnit._037_ vssd1 vssd1 vccd1 vccd1 aluUnit._038_ sky130_fd_sc_hd__nand2_1
XFILLER_25_92 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_2_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_32_150 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_24_117 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_24_139 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._074_ uartUnit.fifoTX.array\[0\]\[6\] uartUnit.fifoTX.array\[1\]\[6\]
+ uartUnit.fifoTX.array\[2\]\[6\] uartUnit.fifoTX.array\[3\]\[6\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[6\]
+ sky130_fd_sc_hd__mux4_1
XuartUnit.fifoTX._143_ net56 uartUnit.fifoTX._009_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_46_253 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._255_ net21 aluUnit._021_ vssd1 vssd1 vccd1 vccd1 aluUnit._022_ sky130_fd_sc_hd__xnor2_1
XaluUnit._324_ aluUnit._085_ aluUnit._086_ vssd1 vssd1 vccd1 vccd1 aluUnit._087_ sky130_fd_sc_hd__xor2_1
XaluUnit._186_ aluUnit.i_op\[0\] aluUnit.i_op\[1\] vssd1 vssd1 vccd1 vccd1 aluUnit._119_
+ sky130_fd_sc_hd__nand2b_2
XPHY_EDGE_ROW_26_Left_75 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_10_Left_59 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._100_ uartUnit.uartRxUnit._032_ uartUnit.uartRxUnit._046_ uartUnit.uartRxUnit._047_
+ uartUnit.uartRxUnit._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._051_ sky130_fd_sc_hd__nor4_1
XFILLER_12_109 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_43_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_43_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_28_286 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.fifoTX._126_ uartUnit.fifoTX.array\[3\]\[0\] alu_uart_interfaceUnit.o_data_to_write\[0\]
+ uartUnit.fifoTX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._034_ sky130_fd_sc_hd__mux2_1
XFILLER_11_164 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_11_175 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_34_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_34_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_34_245 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._238_ aluUnit._004_ aluUnit._005_ vssd1 vssd1 vccd1 vccd1 aluUnit._006_ sky130_fd_sc_hd__nor2_1
XaluUnit._307_ aluUnit.i_data_a\[6\] aluUnit._069_ vssd1 vssd1 vccd1 vccd1 aluUnit._071_
+ sky130_fd_sc_hd__or2_1
XaluUnit._169_ net30 aluUnit._097_ aluUnit._101_ vssd1 vssd1 vccd1 vccd1 aluUnit._102_
+ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_4_127 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_37 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
Xalu_uart_interfaceUnit._180_ alu_uart_interfaceUnit.o_data_to_write\[4\] aluUnit.o_alu_result\[4\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._086_
+ sky130_fd_sc_hd__mux2_1
XFILLER_25_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_25_267 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_25_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_4_105 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._109_ uartUnit.fifoTX.read_ptr\[1\] uartUnit.fifoTX._050_ uartUnit.fifoTX._052_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._027_ sky130_fd_sc_hd__o21a_1
XuartUnit.fifoRX._173_ net47 uartUnit.fifoRX._039_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_31_204 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_31_237 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_12_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._170_ net61 uartUnit.uartTxUnit._015_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_108 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout19 net20 vssd1 vssd1 vccd1 vccd1 net19 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_32_265 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_48 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_38_26 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_13_Left_62 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._163_ net34 alu_uart_interfaceUnit._077_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._025_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_23_221 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._094_ alu_uart_interfaceUnit.state\[3\] vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._090_ sky130_fd_sc_hd__inv_2
XFILLER_0_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_48_167 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_335 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._156_ net42 uartUnit.fifoRX._022_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._087_ uartUnit.fifoRX.i_data_to_write\[0\] uartUnit.fifoRX.array\[0\]\[0\]
+ uartUnit.fifoRX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._010_ sky130_fd_sc_hd__mux2_1
XFILLER_39_178 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._153_ uartUnit.uartTxUnit.send_byte\[7\] uartUnit.uartTxUnit._023_
+ uartUnit.uartTxUnit._038_ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._018_
+ sky130_fd_sc_hd__o211a_1
XuartUnit.uartTxUnit._084_ net10 uartUnit.uartTxUnit._044_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit._046_ sky130_fd_sc_hd__nand2_1
XFILLER_40_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._146_ alu_uart_interfaceUnit.i_data_to_read\[3\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._069_ sky130_fd_sc_hd__or2_1
Xalu_uart_interfaceUnit._215_ net48 alu_uart_interfaceUnit._027_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[5\] sky130_fd_sc_hd__dfxtp_2
XFILLER_36_104 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.baud_rateUnit._67_ net49 uartUnit.baud_rateUnit._06_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_181 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoRX._139_ net42 uartUnit.fifoRX._005_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Left_89 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_27_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._136_ uartUnit.uartTxUnit.send_byte\[1\] net5 uartUnit.uartTxUnit._027_
+ uartUnit.uartTxUnit._043_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._012_ sky130_fd_sc_hd__o211a_1
XuartUnit.fifoTX._090_ alu_uart_interfaceUnit.o_data_to_write\[3\] uartUnit.fifoTX.array\[0\]\[3\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._013_ sky130_fd_sc_hd__mux2_1
XFILLER_2_214 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_33_107 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._271_ aluUnit.i_data_b\[0\] net21 net24 net28 vssd1 vssd1 vccd1 vccd1 aluUnit._037_
+ sky130_fd_sc_hd__or4_1
Xalu_uart_interfaceUnit._129_ aluUnit.i_op\[0\] alu_uart_interfaceUnit._051_ alu_uart_interfaceUnit._060_
+ net33 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._008_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_10_Right_10 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_198 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_59 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._142_ net56 uartUnit.fifoTX._008_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._119_ net14 uartUnit.uartTxUnit._045_ uartUnit.uartTxUnit._070_
+ uartUnit.uartTxUnit.n\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._072_ sky130_fd_sc_hd__a31o_1
XuartUnit.fifoTX._073_ uartUnit.fifoTX.array\[0\]\[5\] uartUnit.fifoTX.array\[1\]\[5\]
+ uartUnit.fifoTX.array\[2\]\[5\] uartUnit.fifoTX.array\[3\]\[5\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[5\]
+ sky130_fd_sc_hd__mux4_1
XFILLER_46_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_1_Left_50 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._254_ net29 net24 net28 aluUnit._119_ aluUnit._125_ vssd1 vssd1 vccd1 vccd1
+ aluUnit._021_ sky130_fd_sc_hd__o32a_1
XaluUnit._323_ aluUnit.i_data_b\[5\] aluUnit.i_data_b\[4\] aluUnit.i_data_b\[6\] aluUnit._037_
+ aluUnit._137_ vssd1 vssd1 vccd1 vccd1 aluUnit._086_ sky130_fd_sc_hd__o41a_1
XaluUnit._185_ net25 aluUnit._117_ aluUnit._100_ vssd1 vssd1 vccd1 vccd1 aluUnit._118_
+ sky130_fd_sc_hd__a21o_1
XFILLER_42_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_37_276 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_16_29 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Left_92 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_293 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._125_ uartUnit.fifoTX.write_ptr\[1\] uartUnit.fifoTX.write_ptr\[0\]
+ uartUnit.fifoTX._045_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._064_ sky130_fd_sc_hd__and3_4
XFILLER_7_169 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_8_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_8_74 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._237_ aluUnit._141_ aluUnit._142_ aluUnit._140_ vssd1 vssd1 vccd1 vccd1 aluUnit._005_
+ sky130_fd_sc_hd__a21oi_2
XaluUnit._168_ aluUnit.i_data_a\[6\] aluUnit._098_ net30 vssd1 vssd1 vccd1 vccd1 aluUnit._101_
+ sky130_fd_sc_hd__a21oi_1
XaluUnit._306_ aluUnit.i_data_a\[6\] aluUnit._069_ vssd1 vssd1 vccd1 vccd1 aluUnit._070_
+ sky130_fd_sc_hd__nand2_1
XFILLER_6_191 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_40_216 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_33_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_25_279 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_4_117 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.fifoTX._108_ uartUnit.fifoTX.read_ptr\[1\] uartUnit.fifoTX._050_ net39 vssd1
+ vssd1 vccd1 vccd1 uartUnit.fifoTX._052_ sky130_fd_sc_hd__a21oi_1
XuartUnit.fifoRX._172_ net42 uartUnit.fifoRX._038_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_31_216 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_31_249 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_109 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Right_8 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_266 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_39_Right_39 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Right_48 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
Xalu_uart_interfaceUnit._162_ net21 alu_uart_interfaceUnit.i_data_to_read\[3\] alu_uart_interfaceUnit._053_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._077_ sky130_fd_sc_hd__mux2_1
XFILLER_13_216 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_222 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_153 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_336 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._155_ net42 uartUnit.fifoRX._021_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_8_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._086_ uartUnit.fifoRX.o_fifo_is_full uartUnit.fifoRX.write_ptr\[1\]
+ uartUnit.fifoRX.write_ptr\[0\] uartUnit.fifoRX._044_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._047_
+ sky130_fd_sc_hd__or4_4
XFILLER_5_20 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartTxUnit._152_ uartUnit.uartTxUnit._040_ uartUnit.fifoTX.o_data_to_read\[7\]
+ net7 net6 uartUnit.uartTxUnit._022_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._038_
+ sky130_fd_sc_hd__a2111o_1
XuartUnit.uartTxUnit._083_ net10 uartUnit.uartTxUnit._044_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit._045_ sky130_fd_sc_hd__and2_1
XFILLER_10_219 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_203 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._214_ net48 alu_uart_interfaceUnit._026_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[4\] sky130_fd_sc_hd__dfxtp_2
Xalu_uart_interfaceUnit._145_ net32 alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._068_
+ net34 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._016_ sky130_fd_sc_hd__o211a_1
XFILLER_5_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_5_256 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_5_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_39_92 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_36_138 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.baud_rateUnit._66_ net49 uartUnit.baud_rateUnit._05_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[5\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._069_ uartUnit.fifoRX.array\[0\]\[1\] uartUnit.fifoRX.array\[1\]\[1\]
+ uartUnit.fifoRX.array\[2\]\[1\] uartUnit.fifoRX.array\[3\]\[1\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[1\]
+ sky130_fd_sc_hd__mux4_1
XuartUnit.fifoRX._138_ net42 uartUnit.fifoRX._004_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_42_108 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._135_ net8 uartUnit.uartTxUnit._058_ uartUnit.uartTxUnit._022_
+ uartUnit.uartTxUnit._026_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._027_ sky130_fd_sc_hd__or4_1
XaluUnit._270_ aluUnit._028_ aluUnit._030_ aluUnit._034_ aluUnit._036_ vssd1 vssd1
+ vccd1 vccd1 aluUnit.o_alu_result\[3\] sky130_fd_sc_hd__a211o_1
Xalu_uart_interfaceUnit._128_ alu_uart_interfaceUnit.i_data_to_read\[0\] net20 alu_uart_interfaceUnit._050_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._060_ sky130_fd_sc_hd__or3_1
XFILLER_1_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.baud_rateUnit._49_ uartUnit.baud_rateUnit._15_ uartUnit.baud_rateUnit._21_
+ uartUnit.baud_rateUnit._22_ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._04_
+ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_19_199 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._118_ uartUnit.uartTxUnit.state\[0\] uartUnit.uartTxUnit.state\[3\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._071_ sky130_fd_sc_hd__or2_1
XuartUnit.fifoTX._072_ uartUnit.fifoTX.array\[0\]\[4\] uartUnit.fifoTX.array\[1\]\[4\]
+ uartUnit.fifoTX.array\[2\]\[4\] uartUnit.fifoTX.array\[3\]\[4\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[4\]
+ sky130_fd_sc_hd__mux4_1
XuartUnit.fifoTX._141_ net58 uartUnit.fifoTX._007_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_2_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._322_ aluUnit._083_ aluUnit._084_ vssd1 vssd1 vccd1 vccd1 aluUnit._085_ sky130_fd_sc_hd__or2_1
XaluUnit._253_ aluUnit._004_ aluUnit._005_ aluUnit._002_ vssd1 vssd1 vccd1 vccd1 aluUnit._020_
+ sky130_fd_sc_hd__o21a_1
XFILLER_14_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._184_ net30 aluUnit._116_ aluUnit._101_ vssd1 vssd1 vccd1 vccd1 aluUnit._117_
+ sky130_fd_sc_hd__a21o_1
XFILLER_35_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_180 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_294 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._124_ uartUnit.fifoTX._061_ uartUnit.fifoTX._063_ net39 vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoTX._033_ sky130_fd_sc_hd__a21o_1
XuartUnit.uartRxUnit._089_ net9 uartUnit.uartRxUnit._043_ uartUnit.uartRxUnit._042_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._044_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_9 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_47_81 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_34_269 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XaluUnit._305_ aluUnit.i_data_b\[6\] aluUnit._068_ vssd1 vssd1 vccd1 vccd1 aluUnit._069_
+ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_29_250 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._236_ aluUnit._002_ aluUnit._003_ vssd1 vssd1 vccd1 vccd1 aluUnit._004_ sky130_fd_sc_hd__nand2_1
XaluUnit._167_ net13 aluUnit._099_ net25 vssd1 vssd1 vccd1 vccd1 aluUnit._100_ sky130_fd_sc_hd__a21oi_1
XFILLER_40_228 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_25_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_16_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_17_73 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._107_ uartUnit.fifoTX.read_ptr\[0\] uartUnit.fifoTX._049_ uartUnit.fifoTX._051_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._026_ sky130_fd_sc_hd__o21a_1
XuartUnit.fifoRX._171_ net42 uartUnit.fifoRX._037_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_267 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._219_ net26 net13 aluUnit._149_ net22 vssd1 vssd1 vccd1 vccd1 aluUnit._151_
+ sky130_fd_sc_hd__a31o_1
Xalu_uart_interfaceUnit._161_ net33 alu_uart_interfaceUnit._076_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._024_ sky130_fd_sc_hd__and2_1
XFILLER_48_169 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_48_147 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_48_125 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_165 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_28_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_337 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_82 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._154_ net43 uartUnit.fifoRX._020_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_8_221 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_8_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._085_ uartUnit.fifoRX.array\[2\]\[7\] uartUnit.fifoRX.i_data_to_write\[7\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._009_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartTxUnit._151_ uartUnit.uartTxUnit.send_byte\[6\] uartUnit.uartTxUnit._023_
+ uartUnit.uartTxUnit._037_ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._017_
+ sky130_fd_sc_hd__o211a_1
XuartUnit.uartTxUnit._082_ uartUnit.uartTxUnit.s\[3\] uartUnit.uartTxUnit.s\[2\] uartUnit.uartTxUnit.s\[1\]
+ uartUnit.uartTxUnit.s\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._044_ sky130_fd_sc_hd__and4_2
XTAP_TAPCELL_ROW_20_204 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_318 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._213_ net54 alu_uart_interfaceUnit._025_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[3\] sky130_fd_sc_hd__dfxtp_1
Xalu_uart_interfaceUnit._144_ alu_uart_interfaceUnit.i_data_to_read\[2\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._068_ sky130_fd_sc_hd__or2_1
XFILLER_14_41 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_14_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_5_268 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.baud_rateUnit._65_ net50 uartUnit.baud_rateUnit._04_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[4\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._137_ net46 uartUnit.fifoRX._003_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._068_ uartUnit.fifoRX.array\[0\]\[0\] uartUnit.fifoRX.array\[1\]\[0\]
+ uartUnit.fifoRX.array\[2\]\[0\] uartUnit.fifoRX.array\[3\]\[0\] uartUnit.fifoRX._000_
+ uartUnit.fifoRX._001_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_data_to_read\[0\]
+ sky130_fd_sc_hd__mux4_1
XuartUnit.uartTxUnit._134_ uartUnit.fifoTX.o_data_to_read\[1\] uartUnit.uartTxUnit.send_byte\[2\]
+ net15 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._026_ sky130_fd_sc_hd__mux2_1
XFILLER_18_106 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_25_40 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
Xalu_uart_interfaceUnit._127_ alu_uart_interfaceUnit.o_fifo_tx_write alu_uart_interfaceUnit._059_
+ alu_uart_interfaceUnit._058_ net35 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._007_
+ sky130_fd_sc_hd__o211a_1
XFILLER_26_161 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.baud_rateUnit._48_ uartUnit.baud_rateUnit.counter\[4\] uartUnit.baud_rateUnit._19_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._22_ sky130_fd_sc_hd__or2_1
XuartUnit.uartTxUnit._117_ uartUnit.uartTxUnit.state\[0\] uartUnit.uartTxUnit.state\[3\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._070_ sky130_fd_sc_hd__nor2_1
XuartUnit.fifoTX._140_ net60 uartUnit.fifoTX._006_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._071_ uartUnit.fifoTX.array\[0\]\[3\] uartUnit.fifoTX.array\[1\]\[3\]
+ uartUnit.fifoTX.array\[2\]\[3\] uartUnit.fifoTX.array\[3\]\[3\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[3\]
+ sky130_fd_sc_hd__mux4_1
XFILLER_23_175 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_11_42 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_46_278 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_36_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._321_ aluUnit.i_data_b\[7\] aluUnit.i_data_a\[7\] vssd1 vssd1 vccd1 vccd1
+ aluUnit._084_ sky130_fd_sc_hd__and2_1
XaluUnit._252_ aluUnit._006_ aluUnit._007_ aluUnit._019_ vssd1 vssd1 vccd1 vccd1 aluUnit.o_alu_result\[2\]
+ sky130_fd_sc_hd__o21ai_1
XFILLER_14_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._183_ aluUnit.i_data_a\[7\] aluUnit._098_ vssd1 vssd1 vccd1 vccd1 aluUnit._116_
+ sky130_fd_sc_hd__nand2_1
XFILLER_37_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_28_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_20_101 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_181 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_134 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_138 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_237 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_43_204 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_295 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_212 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._088_ uartUnit.uartRxUnit._031_ uartUnit.uartRxUnit._039_ uartUnit.uartRxUnit._037_
+ uartUnit.uartRxUnit.state\[1\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._043_
+ sky130_fd_sc_hd__a2bb2o_1
XuartUnit.fifoTX._123_ uartUnit.fifoTX._058_ uartUnit.fifoTX._062_ uartUnit.fifoTX.o_fifo_is_empty
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._063_ sky130_fd_sc_hd__a21o_1
XFILLER_11_189 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_7_149 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_22_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_34_215 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._235_ net32 aluUnit._001_ vssd1 vssd1 vccd1 vccd1 aluUnit._003_ sky130_fd_sc_hd__or2_1
XFILLER_19_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XaluUnit._304_ aluUnit.i_data_b\[5\] aluUnit._137_ aluUnit._054_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._068_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_29_251 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_65 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_6_171 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._166_ aluUnit.i_data_a\[4\] aluUnit.i_data_a\[5\] net30 vssd1 vssd1 vccd1
+ vccd1 aluUnit._099_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoTX._106_ net39 uartUnit.fifoTX._050_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._051_
+ sky130_fd_sc_hd__nor2_1
XuartUnit.fifoRX._170_ net42 uartUnit.fifoRX._036_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_17_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_33_95 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._218_ aluUnit.i_data_a\[1\] net32 net29 vssd1 vssd1 vccd1 vccd1 aluUnit._150_
+ sky130_fd_sc_hd__mux2_1
XFILLER_15_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_30_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._160_ net24 alu_uart_interfaceUnit.i_data_to_read\[2\] alu_uart_interfaceUnit._053_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._076_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_100 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_159 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_48_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._153_ net46 uartUnit.fifoRX._019_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_5_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_8_233 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_8_277 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._084_ uartUnit.fifoRX.array\[2\]\[6\] uartUnit.fifoRX.i_data_to_write\[6\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._008_ sky130_fd_sc_hd__mux2_1
XFILLER_39_104 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_10_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._150_ net7 net6 uartUnit.uartTxUnit._022_ uartUnit.uartTxUnit._036_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._037_ sky130_fd_sc_hd__or4_1
XuartUnit.uartTxUnit._081_ net39 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._043_
+ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_17_Left_66 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_205 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_319 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._143_ aluUnit.i_data_a\[1\] alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._067_
+ net34 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._015_ sky130_fd_sc_hd__o211a_1
Xalu_uart_interfaceUnit._212_ net48 alu_uart_interfaceUnit._024_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_53 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_5_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_30_41 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_30_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.baud_rateUnit._64_ net50 uartUnit.baud_rateUnit._03_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_29_181 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_44_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoRX._136_ net46 uartUnit.fifoRX._002_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[2\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._067_ uartUnit.fifoRX.i_write_fifo vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._044_
+ sky130_fd_sc_hd__inv_2
XFILLER_27_129 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._133_ uartUnit.uartTxUnit.send_byte\[0\] net5 uartUnit.uartTxUnit._025_
+ uartUnit.uartTxUnit._043_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._011_ sky130_fd_sc_hd__o211a_1
XFILLER_18_118 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_41_154 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_41_121 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._126_ alu_uart_interfaceUnit.i_fifo_tx_full net12 vssd1 vssd1
+ vccd1 vccd1 alu_uart_interfaceUnit._059_ sky130_fd_sc_hd__and2b_2
XFILLER_26_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_41_73 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_41_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.baud_rateUnit._47_ uartUnit.baud_rateUnit.counter\[4\] uartUnit.baud_rateUnit._19_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._21_ sky130_fd_sc_hd__nand2_1
XFILLER_32_165 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._119_ uartUnit.fifoRX._044_ alu_uart_interfaceUnit.o_fifo_rx_read
+ uartUnit.fifoRX._058_ uartUnit.fifoRX._059_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._060_
+ sky130_fd_sc_hd__or4_1
XFILLER_46_29 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._116_ net9 uartUnit.uartTxUnit._044_ uartUnit.uartTxUnit.state\[2\]
+ net14 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._069_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_23_110 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_23_132 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_23_154 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._070_ uartUnit.fifoTX.array\[0\]\[2\] uartUnit.fifoTX.array\[1\]\[2\]
+ uartUnit.fifoTX.array\[2\]\[2\] uartUnit.fifoTX.array\[3\]\[2\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[2\]
+ sky130_fd_sc_hd__mux4_1
XFILLER_11_54 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_36_62 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._251_ aluUnit._134_ aluUnit._009_ aluUnit._014_ aluUnit._016_ aluUnit._018_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._019_ sky130_fd_sc_hd__o2111a_1
XaluUnit._320_ aluUnit.i_data_b\[7\] aluUnit.i_data_a\[7\] vssd1 vssd1 vccd1 vccd1
+ aluUnit._083_ sky130_fd_sc_hd__nor2_1
XaluUnit._182_ aluUnit._105_ aluUnit._114_ aluUnit._109_ vssd1 vssd1 vccd1 vccd1 aluUnit._115_
+ sky130_fd_sc_hd__o21a_1
Xalu_uart_interfaceUnit._109_ alu_uart_interfaceUnit.state\[3\] alu_uart_interfaceUnit.state\[1\]
+ alu_uart_interfaceUnit.state\[0\] alu_uart_interfaceUnit.state\[2\] vssd1 vssd1
+ vccd1 vccd1 alu_uart_interfaceUnit._047_ sky130_fd_sc_hd__nor4b_1
XTAP_TAPCELL_ROW_15_182 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_124 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_20_179 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_139 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_202 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_296 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._122_ alu_uart_interfaceUnit.o_fifo_tx_write uartUnit.fifoTX._059_
+ uartUnit.fifoTX.i_read_fifo vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._062_ sky130_fd_sc_hd__nor3b_1
XuartUnit.uartRxUnit._087_ net9 uartUnit.uartRxUnit._034_ uartUnit.uartRxUnit._030_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._042_ sky130_fd_sc_hd__a21oi_4
XFILLER_7_139 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_11_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Left_54 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_22_97 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_19_279 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_252 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._234_ net32 aluUnit._001_ vssd1 vssd1 vccd1 vccd1 aluUnit._002_ sky130_fd_sc_hd__nand2_1
XaluUnit._303_ aluUnit._059_ aluUnit._061_ aluUnit._067_ vssd1 vssd1 vccd1 vccd1 aluUnit.o_alu_result\[5\]
+ sky130_fd_sc_hd__o21ai_1
XFILLER_27_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_6_183 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_163 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._165_ aluUnit.i_data_b\[5\] aluUnit.i_data_b\[4\] aluUnit.i_data_b\[7\] aluUnit.i_data_b\[6\]
+ vssd1 vssd1 vccd1 vccd1 aluUnit._098_ sky130_fd_sc_hd__nor4_2
XFILLER_40_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_25_205 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_96 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_120 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._105_ uartUnit.fifoTX._042_ alu_uart_interfaceUnit.o_fifo_tx_write
+ uartUnit.fifoTX.i_read_fifo uartUnit.fifoTX.read_ptr\[0\] vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoTX._050_ sky130_fd_sc_hd__o211a_1
XFILLER_17_42 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_233 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._139_ net53 uartUnit.uartRxUnit._002_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.state\[2\] sky130_fd_sc_hd__dfxtp_2
XaluUnit._217_ net31 aluUnit.i_data_a\[4\] net30 vssd1 vssd1 vccd1 vccd1 aluUnit._149_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_101 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Right_17 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_28_41 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_28_63 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_28_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_44_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Right_35 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._152_ net46 uartUnit.fifoRX._018_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[1\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._083_ uartUnit.fifoRX.array\[2\]\[5\] uartUnit.fifoRX.i_data_to_write\[5\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._007_ sky130_fd_sc_hd__mux2_1
XFILLER_8_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_44_Right_44 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_39_116 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._080_ uartUnit.tx_not_empty vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._042_
+ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_20_206 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._211_ net48 alu_uart_interfaceUnit._023_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[1\] sky130_fd_sc_hd__dfxtp_1
Xalu_uart_interfaceUnit._142_ alu_uart_interfaceUnit.i_data_to_read\[1\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._067_ sky130_fd_sc_hd__or2_1
XFILLER_5_215 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_30_97 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_39_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Left_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.baud_rateUnit._63_ net49 uartUnit.baud_rateUnit._02_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._066_ uartUnit.fifoRX.o_fifo_is_full vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._043_
+ sky130_fd_sc_hd__inv_2
XuartUnit.fifoRX._135_ uartUnit.fifoRX.read_ptr\[1\] uartUnit.fifoRX._050_ uartUnit.fifoRX._052_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._031_ sky130_fd_sc_hd__o21a_1
XFILLER_27_119 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartTxUnit._132_ net8 net6 uartUnit.uartTxUnit._022_ uartUnit.uartTxUnit._024_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._025_ sky130_fd_sc_hd__or4_1
XFILLER_41_166 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._125_ alu_uart_interfaceUnit._093_ alu_uart_interfaceUnit._040_
+ alu_uart_interfaceUnit._045_ alu_uart_interfaceUnit.state\[3\] net12 vssd1 vssd1
+ vccd1 vccd1 alu_uart_interfaceUnit._058_ sky130_fd_sc_hd__a221o_1
XFILLER_41_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_17_130 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.baud_rateUnit._46_ uartUnit.baud_rateUnit._19_ uartUnit.baud_rateUnit._20_
+ uartUnit.baud_rateUnit._15_ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._03_
+ sky130_fd_sc_hd__and3b_1
XFILLER_32_144 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_17_196 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoRX._118_ uartUnit.fifoRX.read_ptr\[0\] uartUnit.fifoRX.write_ptr\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._059_ sky130_fd_sc_hd__xnor2_1
XuartUnit.uartTxUnit._115_ uartUnit.uartTxUnit._066_ uartUnit.uartTxUnit._067_ uartUnit.uartTxUnit._068_
+ net40 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._007_ sky130_fd_sc_hd__a211oi_1
XFILLER_23_144 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_36_96 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XaluUnit._250_ net23 net32 aluUnit._131_ aluUnit._017_ vssd1 vssd1 vccd1 vccd1 aluUnit._018_
+ sky130_fd_sc_hd__o31a_1
XFILLER_14_166 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._181_ net22 aluUnit._103_ aluUnit._113_ vssd1 vssd1 vccd1 vccd1 aluUnit._114_
+ sky130_fd_sc_hd__a21oi_1
Xalu_uart_interfaceUnit._108_ alu_uart_interfaceUnit._090_ alu_uart_interfaceUnit.wait_reg\[0\]
+ alu_uart_interfaceUnit._045_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._046_
+ sky130_fd_sc_hd__o21a_1
XFILLER_37_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_9_192 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_70 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_28_247 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_297 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._155_ net45 uartUnit.uartRxUnit._018_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[7\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartRxUnit._086_ net18 uartUnit.uartRxUnit._041_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit._002_ sky130_fd_sc_hd__and2_1
XuartUnit.fifoTX._121_ alu_uart_interfaceUnit.i_fifo_tx_full uartUnit.fifoTX._044_
+ uartUnit.fifoTX.i_read_fifo vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._061_ sky130_fd_sc_hd__or3_1
XFILLER_0_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_47_95 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_34_228 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_19_225 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._233_ net24 aluUnit._000_ vssd1 vssd1 vccd1 vccd1 aluUnit._001_ sky130_fd_sc_hd__xnor2_1
XaluUnit._302_ aluUnit._134_ aluUnit._160_ aluUnit._062_ aluUnit._065_ aluUnit._066_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._067_ sky130_fd_sc_hd__o2111a_1
XaluUnit._164_ aluUnit.i_data_a\[7\] vssd1 vssd1 vccd1 vccd1 aluUnit._097_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_12_164 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_278 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_217 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_121 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_54 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartRxUnit._069_ uartUnit.uartRxUnit.n\[2\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._026_
+ sky130_fd_sc_hd__inv_2
XuartUnit.fifoTX._104_ uartUnit.fifoTX._042_ alu_uart_interfaceUnit.o_fifo_tx_write
+ uartUnit.fifoTX.i_read_fifo vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._049_ sky130_fd_sc_hd__o21a_1
XuartUnit.uartRxUnit._138_ net53 uartUnit.uartRxUnit._001_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.state\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_250 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_234 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._216_ aluUnit.i_data_a\[1\] net28 aluUnit._133_ aluUnit._146_ aluUnit._147_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._148_ sky130_fd_sc_hd__a311o_1
XFILLER_30_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_102 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_209 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_21_286 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_0_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_28_75 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_28_97 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_44_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_44_74 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoRX._082_ uartUnit.fifoRX.array\[2\]\[4\] uartUnit.fifoRX.i_data_to_write\[4\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._006_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._151_ net44 uartUnit.fifoRX._017_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_5_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_39_128 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_207 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_161 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._141_ aluUnit.i_data_a\[0\] alu_uart_interfaceUnit._043_ alu_uart_interfaceUnit._066_
+ net34 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._014_ sky130_fd_sc_hd__o211a_1
Xalu_uart_interfaceUnit._210_ net48 alu_uart_interfaceUnit._022_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_data_b\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_44_153 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.baud_rateUnit._62_ net49 uartUnit.baud_rateUnit._01_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._065_ net19 vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._042_ sky130_fd_sc_hd__inv_2
XuartUnit.fifoRX._134_ uartUnit.fifoRX.read_ptr\[0\] uartUnit.fifoRX._049_ uartUnit.fifoRX._051_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._030_ sky130_fd_sc_hd__o21a_1
XuartUnit.uartTxUnit._131_ uartUnit.fifoTX.o_data_to_read\[0\] uartUnit.uartTxUnit.send_byte\[1\]
+ net15 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._024_ sky130_fd_sc_hd__mux2_1
Xalu_uart_interfaceUnit._124_ net38 alu_uart_interfaceUnit._057_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._006_ sky130_fd_sc_hd__nor2_1
XFILLER_41_97 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_17_164 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.baud_rateUnit._45_ uartUnit.baud_rateUnit.counter\[0\] uartUnit.baud_rateUnit.counter\[1\]
+ uartUnit.baud_rateUnit.counter\[2\] uartUnit.baud_rateUnit.counter\[3\] vssd1 vssd1
+ vccd1 vccd1 uartUnit.baud_rateUnit._20_ sky130_fd_sc_hd__a31o_1
XFILLER_32_178 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._117_ uartUnit.fifoRX.read_ptr\[1\] uartUnit.fifoRX._057_ vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoRX._058_ sky130_fd_sc_hd__xnor2_1
XuartUnit.uartTxUnit._114_ uartUnit.uartTxUnit.s\[3\] uartUnit.uartTxUnit._063_ vssd1
+ vssd1 vccd1 vccd1 uartUnit.uartTxUnit._068_ sky130_fd_sc_hd__nor2_1
XFILLER_23_167 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_46_248 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_36_42 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._180_ net13 aluUnit._110_ net22 vssd1 vssd1 vccd1 vccd1 aluUnit._113_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_178 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._107_ alu_uart_interfaceUnit.state\[2\] alu_uart_interfaceUnit.state\[1\]
+ alu_uart_interfaceUnit.state\[0\] vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._045_
+ sky130_fd_sc_hd__nor3_2
XFILLER_45_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartRxUnit._154_ net45 uartUnit.uartRxUnit._017_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[6\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._120_ uartUnit.fifoTX._056_ uartUnit.fifoTX._060_ net39 vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoTX._032_ sky130_fd_sc_hd__a21oi_1
XuartUnit.uartRxUnit._085_ uartUnit.uartRxUnit._025_ uartUnit.uartRxUnit.state\[0\]
+ uartUnit.uartRxUnit._039_ uartUnit.uartRxUnit.state\[2\] uartUnit.uartRxUnit._040_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._041_ sky130_fd_sc_hd__a221o_1
XFILLER_22_55 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._301_ aluUnit.i_data_b\[5\] aluUnit.i_data_a\[5\] aluUnit._133_ aluUnit._064_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._066_ sky130_fd_sc_hd__a31oi_1
XFILLER_19_237 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._232_ net29 net27 aluUnit._119_ aluUnit._125_ vssd1 vssd1 vccd1 vccd1 aluUnit._000_
+ sky130_fd_sc_hd__o22a_1
XaluUnit._163_ net26 vssd1 vssd1 vccd1 vccd1 aluUnit._096_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_12_165 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_10_192 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_26_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_279 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_122 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_235 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._103_ uartUnit.fifoTX.array\[1\]\[7\] alu_uart_interfaceUnit.o_data_to_write\[7\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._025_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartRxUnit._137_ net50 uartUnit.uartRxUnit._000_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit.state\[0\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartRxUnit._068_ net3 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._025_
+ sky130_fd_sc_hd__inv_2
XaluUnit._215_ aluUnit.i_data_a\[1\] net28 aluUnit._131_ vssd1 vssd1 vccd1 vccd1 aluUnit._147_
+ sky130_fd_sc_hd__nor3_1
XFILLER_30_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_103 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_3_Right_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_260 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_0_169 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._150_ net47 uartUnit.fifoRX._016_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[0\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._081_ uartUnit.fifoRX.array\[2\]\[3\] uartUnit.fifoRX.i_data_to_write\[3\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._005_ sky130_fd_sc_hd__mux2_1
XFILLER_8_247 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_5_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_330 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._140_ alu_uart_interfaceUnit.i_data_to_read\[0\] alu_uart_interfaceUnit._044_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._066_ sky130_fd_sc_hd__or2_1
XFILLER_39_31 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_39_75 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.baud_rateUnit._61_ net49 uartUnit.baud_rateUnit._00_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.baud_rateUnit.counter\[0\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._133_ uartUnit.fifoRX.array\[3\]\[7\] uartUnit.fifoRX.i_data_to_write\[7\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._041_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartTxUnit._130_ net8 uartUnit.uartTxUnit._058_ uartUnit.uartTxUnit._022_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._023_ sky130_fd_sc_hd__nor3_1
XFILLER_35_198 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_35_132 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_41_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_25_11 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._123_ alu_uart_interfaceUnit.o_fifo_rx_read alu_uart_interfaceUnit._055_
+ alu_uart_interfaceUnit._056_ net19 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._057_
+ sky130_fd_sc_hd__o2bb2a_1
XFILLER_26_154 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_26_187 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_2_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.baud_rateUnit._44_ uartUnit.baud_rateUnit.counter\[0\] uartUnit.baud_rateUnit.counter\[1\]
+ uartUnit.baud_rateUnit.counter\[3\] uartUnit.baud_rateUnit.counter\[2\] vssd1 vssd1
+ vccd1 vccd1 uartUnit.baud_rateUnit._19_ sky130_fd_sc_hd__and4_2
XFILLER_32_135 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.fifoRX._116_ uartUnit.fifoRX.write_ptr\[1\] uartUnit.fifoRX.write_ptr\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._057_ sky130_fd_sc_hd__xnor2_1
XuartUnit.uartTxUnit._113_ uartUnit.uartTxUnit._041_ uartUnit.uartTxUnit._044_ net7
+ net11 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._067_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_18_193 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_102 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_23_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_11_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_39_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._106_ net20 alu_uart_interfaceUnit._038_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._044_ sky130_fd_sc_hd__or2_2
XFILLER_22_190 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_150 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_149 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._084_ net9 uartUnit.uartRxUnit.state\[2\] vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartRxUnit._040_ sky130_fd_sc_hd__and2b_1
XFILLER_11_105 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.uartRxUnit._153_ net45 uartUnit.uartRxUnit._016_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_67 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_22_78 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_47_20 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_19_205 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._231_ aluUnit._120_ aluUnit._152_ aluUnit._161_ aluUnit._162_ vssd1 vssd1
+ vccd1 vccd1 aluUnit.o_alu_result\[1\] sky130_fd_sc_hd__a31o_1
XaluUnit._300_ aluUnit.i_data_b\[5\] aluUnit.i_data_a\[5\] aluUnit._131_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._065_ sky130_fd_sc_hd__or3_1
XFILLER_19_249 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_153 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_166 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_33_241 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoTX._102_ uartUnit.fifoTX.array\[1\]\[6\] alu_uart_interfaceUnit.o_data_to_write\[6\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._024_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_9_Left_58 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_16_219 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.uartRxUnit._136_ uartUnit.fifoRX.i_data_to_write\[7\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._024_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._018_
+ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_26_236 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_3_189 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_3_167 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_3_156 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XaluUnit._214_ aluUnit.i_data_a\[1\] net27 aluUnit._124_ aluUnit._145_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._146_ sky130_fd_sc_hd__o22a_1
XFILLER_15_263 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_30_277 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_350 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_104 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_211 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_261 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._119_ uartUnit.uartRxUnit._026_ uartUnit.uartRxUnit._063_ uartUnit.uartRxUnit._059_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._010_ sky130_fd_sc_hd__a21boi_1
XuartUnit.fifoRX._080_ uartUnit.fifoRX.array\[2\]\[2\] uartUnit.fifoRX.i_data_to_write\[2\]
+ uartUnit.fifoRX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._004_ sky130_fd_sc_hd__mux2_1
XFILLER_47_163 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_331 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Right_22 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_7_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_38_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_39_43 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.baud_rateUnit._60_ uartUnit.baud_rateUnit._10_ uartUnit.baud_rateUnit._25_
+ uartUnit.baud_rateUnit._28_ uartUnit.baud_rateUnit._29_ uartUnit.baud_rateUnit._15_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._08_ sky130_fd_sc_hd__o311a_1
Xalu_uart_interfaceUnit._199_ net46 alu_uart_interfaceUnit._011_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_op\[3\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._132_ uartUnit.fifoRX.array\[3\]\[6\] uartUnit.fifoRX.i_data_to_write\[6\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._040_ sky130_fd_sc_hd__mux2_1
XFILLER_41_169 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._122_ alu_uart_interfaceUnit.state\[2\] alu_uart_interfaceUnit._040_
+ alu_uart_interfaceUnit._050_ alu_uart_interfaceUnit._038_ vssd1 vssd1 vccd1 vccd1
+ alu_uart_interfaceUnit._056_ sky130_fd_sc_hd__o211a_1
XFILLER_41_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_38_Left_87 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_1_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_1_243 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_2_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.baud_rateUnit._43_ uartUnit.baud_rateUnit._15_ uartUnit.baud_rateUnit._17_
+ uartUnit.baud_rateUnit._18_ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._02_
+ sky130_fd_sc_hd__and3_1
XFILLER_32_114 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_17_100 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_40_180 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._115_ uartUnit.fifoRX._042_ uartUnit.fifoRX._044_ alu_uart_interfaceUnit.o_fifo_rx_read
+ uartUnit.fifoRX._043_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._056_ sky130_fd_sc_hd__a31o_1
XuartUnit.uartTxUnit._112_ net7 net6 uartUnit.uartTxUnit.s\[3\] vssd1 vssd1 vccd1
+ vccd1 uartUnit.uartTxUnit._066_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_18_194 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_169 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_11_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_31_191 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_46_239 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._105_ net19 alu_uart_interfaceUnit._038_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._043_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_9_151 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_217 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_20_128 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_9_162 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XuartUnit.uartRxUnit._152_ net43 uartUnit.uartRxUnit._015_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[4\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartRxUnit._083_ uartUnit.uartRxUnit.s\[3\] uartUnit.uartRxUnit.s\[2\] uartUnit.uartRxUnit.s\[1\]
+ uartUnit.uartRxUnit.s\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._039_ sky130_fd_sc_hd__nand4b_4
XFILLER_47_32 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_19_217 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_42_275 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_42_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_8_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._230_ aluUnit._143_ aluUnit._144_ aluUnit._148_ aluUnit._158_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._162_ sky130_fd_sc_hd__a211o_1
XFILLER_6_165 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_167 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_Left_74 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._101_ uartUnit.fifoTX.array\[1\]\[5\] alu_uart_interfaceUnit.o_data_to_write\[5\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._023_ sky130_fd_sc_hd__mux2_1
XFILLER_24_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_237 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._135_ net3 uartUnit.uartRxUnit._042_ uartUnit.uartRxUnit._057_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._024_ sky130_fd_sc_hd__or3_1
XaluUnit._213_ aluUnit.i_data_a\[1\] net28 aluUnit._127_ vssd1 vssd1 vccd1 vccd1 aluUnit._145_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_30_245 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_30_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_351 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_105 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_218 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_80 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_262 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_109 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._118_ uartUnit.uartRxUnit._059_ uartUnit.uartRxUnit._063_ uartUnit.uartRxUnit._064_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._009_ sky130_fd_sc_hd__and3_1
XFILLER_5_49 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_47_142 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_332 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_38_153 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_61 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_30_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_39_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_44_189 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_313 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._198_ net46 alu_uart_interfaceUnit._010_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_op\[2\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._131_ uartUnit.fifoRX.array\[3\]\[5\] uartUnit.fifoRX.i_data_to_write\[5\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._039_ sky130_fd_sc_hd__mux2_1
XFILLER_35_178 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._121_ net19 alu_uart_interfaceUnit._045_ alu_uart_interfaceUnit._047_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._055_ sky130_fd_sc_hd__a21o_1
XFILLER_25_68 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_1_200 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_9_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_1_255 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.baud_rateUnit._42_ uartUnit.baud_rateUnit.counter\[0\] uartUnit.baud_rateUnit.counter\[1\]
+ uartUnit.baud_rateUnit.counter\[2\] vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._18_
+ sky130_fd_sc_hd__a21o_1
XFILLER_40_192 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.fifoRX._114_ uartUnit.fifoRX.write_ptr\[1\] uartUnit.fifoRX._054_ uartUnit.fifoRX._055_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._029_ sky130_fd_sc_hd__o21a_1
XFILLER_48_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._111_ uartUnit.uartTxUnit._062_ uartUnit.uartTxUnit._064_ uartUnit.uartTxUnit._065_
+ net40 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._006_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_18_195 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_34 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
Xalu_uart_interfaceUnit._104_ alu_uart_interfaceUnit._039_ alu_uart_interfaceUnit._042_
+ net35 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._001_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_9_152 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_20_107 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_36_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartRxUnit._082_ uartUnit.uartRxUnit._029_ uartUnit.uartRxUnit._035_ uartUnit.uartRxUnit._038_
+ uartUnit.uartRxUnit._036_ net18 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._003_
+ sky130_fd_sc_hd__o311a_1
XuartUnit.uartRxUnit._151_ net43 uartUnit.uartRxUnit._014_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_25 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_133 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_287 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_42_265 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_290 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_6_122 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_18_251 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._289_ aluUnit.i_data_b\[4\] aluUnit._037_ aluUnit._137_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._054_ sky130_fd_sc_hd__o21a_1
XuartUnit.fifoTX._100_ uartUnit.fifoTX.array\[1\]\[4\] alu_uart_interfaceUnit.o_data_to_write\[4\]
+ uartUnit.fifoTX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._022_ sky130_fd_sc_hd__mux2_1
XuartUnit.uartRxUnit._134_ uartUnit.fifoRX.i_data_to_write\[6\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._023_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._017_
+ sky130_fd_sc_hd__o211a_1
XFILLER_24_265 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Left_91 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_15_243 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._212_ aluUnit._141_ aluUnit._142_ aluUnit._126_ vssd1 vssd1 vccd1 vccd1 aluUnit._144_
+ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_48_352 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_106 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_21_235 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_219 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._117_ uartUnit.uartRxUnit.n\[0\] uartUnit.uartRxUnit._058_ uartUnit.uartRxUnit._060_
+ uartUnit.uartRxUnit.n\[1\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._064_ sky130_fd_sc_hd__a31o_1
XFILLER_12_279 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_20_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_47_154 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Right_7 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_14_15 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_14_26 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_30_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_44_157 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_314 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoRX._130_ uartUnit.fifoRX.array\[3\]\[4\] uartUnit.fifoRX.i_data_to_write\[4\]
+ uartUnit.fifoRX._064_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._038_ sky130_fd_sc_hd__mux2_1
Xalu_uart_interfaceUnit._197_ net54 alu_uart_interfaceUnit._009_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_op\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_4_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._120_ alu_uart_interfaceUnit._041_ alu_uart_interfaceUnit._048_
+ alu_uart_interfaceUnit._054_ net35 vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._005_
+ sky130_fd_sc_hd__o211a_1
XFILLER_1_267 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_1_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_2_29 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_17_113 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.baud_rateUnit._41_ uartUnit.baud_rateUnit.counter\[0\] uartUnit.baud_rateUnit.counter\[1\]
+ uartUnit.baud_rateUnit.counter\[2\] vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._17_
+ sky130_fd_sc_hd__nand3_1
XuartUnit.fifoRX._113_ uartUnit.fifoRX.write_ptr\[1\] uartUnit.fifoRX._054_ net38
+ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._055_ sky130_fd_sc_hd__a21oi_1
XFILLER_31_90 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartTxUnit._110_ uartUnit.uartTxUnit.s\[1\] uartUnit.uartTxUnit.s\[0\] uartUnit.uartTxUnit.s\[2\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._065_ sky130_fd_sc_hd__a21oi_1
XFILLER_16_190 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_196 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_105 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._103_ alu_uart_interfaceUnit._041_ alu_uart_interfaceUnit.wait_reg\[1\]
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._042_ sky130_fd_sc_hd__and2b_1
XuartUnit.uartRxUnit._081_ uartUnit.uartRxUnit._030_ uartUnit.uartRxUnit._037_ vssd1
+ vssd1 vccd1 vccd1 uartUnit.uartRxUnit._038_ sky130_fd_sc_hd__nor2_1
XuartUnit.uartRxUnit._150_ net43 uartUnit.uartRxUnit._013_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX.i_data_to_write\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_6_134 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_244 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_37_291 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_26_7 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._288_ aluUnit._126_ aluUnit._046_ aluUnit._047_ aluUnit._048_ aluUnit._053_
+ vssd1 vssd1 vccd1 vccd1 aluUnit.o_alu_result\[4\] sky130_fd_sc_hd__a311o_1
XuartUnit.uartRxUnit._133_ uartUnit.fifoRX.i_data_to_write\[7\] uartUnit.uartRxUnit._042_
+ uartUnit.uartRxUnit._057_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._023_ sky130_fd_sc_hd__or3_1
XaluUnit._211_ aluUnit._141_ aluUnit._142_ vssd1 vssd1 vccd1 vccd1 aluUnit._143_ sky130_fd_sc_hd__nand2_1
XFILLER_15_255 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoTX._159_ net56 uartUnit.fifoTX._025_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_107 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartRxUnit._116_ uartUnit.uartRxUnit.n\[1\] uartUnit.uartRxUnit.n\[0\] uartUnit.uartRxUnit._058_
+ uartUnit.uartRxUnit._060_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._063_ sky130_fd_sc_hd__nand4_1
XFILLER_12_203 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_12_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_47_177 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_47_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_30_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_39_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_29_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_315 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._196_ net54 alu_uart_interfaceUnit._008_ vssd1 vssd1 vccd1
+ vccd1 aluUnit.i_op\[0\] sky130_fd_sc_hd__dfxtp_2
XFILLER_4_210 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_4_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_50 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_25_48 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_1_279 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.baud_rateUnit._40_ uartUnit.baud_rateUnit._13_ uartUnit.baud_rateUnit._16_
+ uartUnit.baud_rateUnit._15_ vssd1 vssd1 vccd1 vccd1 uartUnit.baud_rateUnit._01_
+ sky130_fd_sc_hd__a21boi_1
XFILLER_32_139 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._179_ net37 alu_uart_interfaceUnit._085_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._033_ sky130_fd_sc_hd__and2_1
XuartUnit.fifoRX._112_ net38 uartUnit.fifoRX._053_ uartUnit.fifoRX._054_ vssd1 vssd1
+ vccd1 vccd1 uartUnit.fifoRX._028_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_18_197 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartTxUnit._169_ net61 uartUnit.uartTxUnit._014_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_117 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._102_ alu_uart_interfaceUnit._091_ alu_uart_interfaceUnit._038_
+ alu_uart_interfaceUnit._041_ alu_uart_interfaceUnit.wait_reg\[0\] net35 vssd1 vssd1
+ vccd1 vccd1 alu_uart_interfaceUnit._000_ sky130_fd_sc_hd__o221a_1
XFILLER_22_172 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_22_183 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_178 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_36_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._080_ uartUnit.uartRxUnit.n\[2\] uartUnit.uartRxUnit.n\[1\] uartUnit.uartRxUnit.n\[0\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._037_ sky130_fd_sc_hd__nand3_1
XFILLER_47_13 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_135 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_57 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_292 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_248 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Right_29 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._175_ net56 uartUnit.fifoTX._041_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_8_29 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_6_102 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_33_9 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Right_47 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_18_242 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_33_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._287_ aluUnit._118_ aluUnit._134_ aluUnit._052_ vssd1 vssd1 vccd1 vccd1 aluUnit._053_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_18_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.uartRxUnit._132_ uartUnit.fifoRX.i_data_to_write\[5\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._022_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._016_
+ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_34_273 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_37 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_24_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoTX._158_ net56 uartUnit.fifoTX._024_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XaluUnit._210_ aluUnit.i_data_a\[0\] net29 vssd1 vssd1 vccd1 vccd1 aluUnit._142_ sky130_fd_sc_hd__nand2b_1
XFILLER_15_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_29_Left_78 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoTX._089_ alu_uart_interfaceUnit.o_data_to_write\[2\] uartUnit.fifoTX.array\[0\]\[2\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._012_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_343 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_0_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_28_26 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.uartRxUnit._115_ net17 uartUnit.uartRxUnit._061_ uartUnit.uartRxUnit._062_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._008_ sky130_fd_sc_hd__and3_1
XFILLER_47_189 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_34_91 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_11_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_38_101 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_30_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_44_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_39_69 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_29_167 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_316 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._195_ net57 alu_uart_interfaceUnit._007_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_fifo_tx_write sky130_fd_sc_hd__dfxtp_2
XFILLER_4_244 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_4_222 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_4_277 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_62 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_16_Left_65 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_26_137 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_25_16 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_26_148 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_41_15 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_1_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._178_ alu_uart_interfaceUnit.o_data_to_write\[3\] aluUnit.o_alu_result\[3\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._085_
+ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._111_ uartUnit.fifoRX._043_ alu_uart_interfaceUnit.o_fifo_rx_read
+ uartUnit.fifoRX.i_write_fifo uartUnit.fifoRX.write_ptr\[0\] vssd1 vssd1 vccd1 vccd1
+ uartUnit.fifoRX._054_ sky130_fd_sc_hd__o211a_1
XFILLER_25_181 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_36_15 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartTxUnit._168_ net60 uartUnit.uartTxUnit._013_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[2\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._099_ uartUnit.uartTxUnit.state\[2\] uartUnit.uartTxUnit.state\[3\]
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._056_ sky130_fd_sc_hd__nor2_1
Xalu_uart_interfaceUnit._101_ net19 alu_uart_interfaceUnit._093_ alu_uart_interfaceUnit._040_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._041_ sky130_fd_sc_hd__and3_1
XFILLER_7_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_13_151 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_9_111 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_13_173 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_179 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_47_69 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_136 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._174_ net56 uartUnit.fifoTX._040_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_27_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_249 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_114 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_12_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_18_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_18_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._286_ aluUnit.i_data_b\[4\] aluUnit.i_data_a\[4\] aluUnit._131_ aluUnit._049_
+ aluUnit._051_ vssd1 vssd1 vccd1 vccd1 aluUnit._052_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_11_160 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._131_ uartUnit.fifoRX.i_data_to_write\[6\] uartUnit.uartRxUnit._042_
+ uartUnit.uartRxUnit._057_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._022_ sky130_fd_sc_hd__or3_1
XFILLER_24_213 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_274 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._157_ net60 uartUnit.fifoTX._023_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_4_Left_53 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_230 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._088_ alu_uart_interfaceUnit.o_data_to_write\[1\] uartUnit.fifoTX.array\[0\]\[1\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._011_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_344 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._269_ aluUnit._120_ aluUnit._027_ aluUnit._035_ aluUnit._126_ aluUnit._025_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._036_ sky130_fd_sc_hd__a32o_1
XFILLER_21_205 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_21_249 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_0_109 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_300 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_49 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_46_Left_95 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartRxUnit._114_ uartUnit.uartRxUnit.state\[1\] uartUnit.uartRxUnit._058_
+ uartUnit.uartRxUnit._060_ uartUnit.uartRxUnit.n\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._062_
+ sky130_fd_sc_hd__a31o_1
XFILLER_8_209 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_12_249 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Left_79 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_47_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_38_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_22_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_14_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_37_190 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_29_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_317 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
Xalu_uart_interfaceUnit._194_ net53 alu_uart_interfaceUnit._006_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.o_fifo_rx_read sky130_fd_sc_hd__dfxtp_1
XFILLER_4_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_4_234 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_29_81 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_85 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_41_27 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_25_28 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._110_ uartUnit.fifoRX.i_write_fifo alu_uart_interfaceUnit.o_fifo_rx_read
+ uartUnit.fifoRX._045_ uartUnit.fifoRX.write_ptr\[0\] vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._053_
+ sky130_fd_sc_hd__a211oi_1
XFILLER_25_193 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._177_ net37 alu_uart_interfaceUnit._084_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._032_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_33_Left_82 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_0_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_16_171 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_36_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._100_ alu_uart_interfaceUnit.state\[1\] alu_uart_interfaceUnit.state\[0\]
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._040_ sky130_fd_sc_hd__or2_1
XuartUnit.uartTxUnit._167_ net60 uartUnit.uartTxUnit._012_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[1\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._098_ net40 uartUnit.uartTxUnit._055_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit._003_ sky130_fd_sc_hd__nor2_1
XFILLER_22_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_45_277 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_9_134 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_13_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_13_185 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_42_81 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_36_277 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_47_48 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_137 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._173_ net60 uartUnit.fifoTX._039_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_12_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_18_277 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._285_ aluUnit.i_data_b\[4\] aluUnit.i_data_a\[4\] aluUnit._124_ aluUnit._050_
+ vssd1 vssd1 vccd1 vccd1 aluUnit._051_ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_11_161 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_118 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_275 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._130_ uartUnit.fifoRX.i_data_to_write\[4\] uartUnit.uartRxUnit._065_
+ uartUnit.uartRxUnit._021_ net17 vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._015_
+ sky130_fd_sc_hd__o211a_1
XFILLER_24_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_15_225 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._156_ net60 uartUnit.fifoTX._022_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._087_ alu_uart_interfaceUnit.o_data_to_write\[0\] uartUnit.fifoTX.array\[0\]\[0\]
+ uartUnit.fifoTX._047_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._010_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_231 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_217 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_2_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_345 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._199_ aluUnit.i_data_a\[0\] net29 aluUnit._131_ vssd1 vssd1 vccd1 vccd1 aluUnit._132_
+ sky130_fd_sc_hd__nor3_1
XaluUnit._268_ net30 net25 aluUnit._116_ net22 vssd1 vssd1 vccd1 vccd1 aluUnit._035_
+ sky130_fd_sc_hd__o31ai_1
XTAP_TAPCELL_ROW_39_301 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_27 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.uartRxUnit._113_ uartUnit.uartRxUnit.n\[0\] uartUnit.uartRxUnit._058_ uartUnit.uartRxUnit._060_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._061_ sky130_fd_sc_hd__nand3_1
XFILLER_20_250 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_20_261 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_18_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_18_94 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._139_ net58 uartUnit.fifoTX._005_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_7_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_15_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_46_180 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_30_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_29_125 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_44_117 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._193_ net53 alu_uart_interfaceUnit._005_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.state\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_29_169 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_20_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_29_93 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_6_20 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_41_109 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_41_39 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_15_73 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._176_ alu_uart_interfaceUnit.o_data_to_write\[2\] aluUnit.o_alu_result\[2\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._084_
+ sky130_fd_sc_hd__mux2_1
XFILLER_40_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_31_72 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xoutput4 net4 vssd1 vssd1 vccd1 vccd1 o_uartTx sky130_fd_sc_hd__buf_2
XFILLER_48_253 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._169_ net46 uartUnit.fifoRX._035_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._166_ net62 uartUnit.uartTxUnit._011_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.send_byte\[0\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._097_ uartUnit.uartTxUnit.state\[3\] uartUnit.uartTxUnit._046_
+ uartUnit.uartTxUnit._054_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._055_ sky130_fd_sc_hd__a21oi_1
XFILLER_45_223 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_45_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
Xalu_uart_interfaceUnit._159_ net33 alu_uart_interfaceUnit._075_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._023_ sky130_fd_sc_hd__and2_1
XFILLER_9_113 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_13_197 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_26_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_36_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_27_234 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XuartUnit.uartTxUnit._149_ uartUnit.fifoTX.o_data_to_read\[6\] uartUnit.uartTxUnit.send_byte\[7\]
+ net15 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._036_ sky130_fd_sc_hd__mux2_1
XFILLER_42_226 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_42_215 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoTX._172_ net60 uartUnit.fifoTX._038_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_10_134 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_6_138 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_12_85 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_18_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_41_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_162 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._284_ aluUnit.i_data_b\[4\] aluUnit.i_data_a\[4\] aluUnit._127_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._050_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_25_Right_25 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_34 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_119 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_276 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_43_Right_43 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_232 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.fifoTX._155_ net59 uartUnit.fifoTX._021_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_23_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.fifoTX._086_ alu_uart_interfaceUnit.i_fifo_tx_full uartUnit.fifoTX.write_ptr\[1\]
+ uartUnit.fifoTX.write_ptr\[0\] uartUnit.fifoTX._044_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._047_
+ sky130_fd_sc_hd__or4_4
XTAP_TAPCELL_ROW_48_346 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_81 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_0_55 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_9_53 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XaluUnit._267_ net21 net31 aluUnit._133_ aluUnit._032_ aluUnit._033_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._034_ sky130_fd_sc_hd__a311o_1
XaluUnit._198_ aluUnit.i_op\[0\] aluUnit.i_op\[1\] aluUnit._122_ vssd1 vssd1 vccd1
+ vccd1 aluUnit._131_ sky130_fd_sc_hd__nand3_4
XFILLER_28_29 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_44_39 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_302 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XuartUnit.uartRxUnit._112_ net9 uartUnit.uartRxUnit._034_ uartUnit.uartRxUnit._037_
+ uartUnit.uartRxUnit._030_ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._060_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_22_213 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_61 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._138_ net58 uartUnit.fifoTX._004_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_34_83 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._069_ uartUnit.fifoTX.array\[0\]\[1\] uartUnit.fifoTX.array\[1\]\[1\]
+ uartUnit.fifoTX.array\[2\]\[1\] uartUnit.fifoTX.array\[3\]\[1\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[1\]
+ sky130_fd_sc_hd__mux4_1
XaluUnit._319_ aluUnit._126_ aluUnit._074_ aluUnit._075_ aluUnit._082_ vssd1 vssd1
+ vccd1 vccd1 aluUnit.o_alu_result\[6\] sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_2_Right_2 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_29_137 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_44_129 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._192_ net53 alu_uart_interfaceUnit._004_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.state\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_74 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_45_82 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_19_181 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_34_195 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_9_9 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
Xalu_uart_interfaceUnit._175_ net37 alu_uart_interfaceUnit._083_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit._031_ sky130_fd_sc_hd__and2_1
XFILLER_48_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_48_265 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoRX._168_ net46 uartUnit.fifoRX._034_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX.array\[3\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoRX._099_ uartUnit.fifoRX.array\[1\]\[3\] uartUnit.fifoRX.i_data_to_write\[3\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._021_ sky130_fd_sc_hd__mux2_1
XFILLER_39_221 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.uartTxUnit._165_ net51 uartUnit.uartTxUnit._010_ vssd1 vssd1 vccd1 vccd1
+ uartUnit.uartTxUnit.n\[2\] sky130_fd_sc_hd__dfxtp_1
XuartUnit.uartTxUnit._096_ net14 net9 uartUnit.uartTxUnit._044_ uartUnit.uartTxUnit._049_
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._054_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_17_190 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_154 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
Xalu_uart_interfaceUnit._158_ net28 alu_uart_interfaceUnit.i_data_to_read\[1\] alu_uart_interfaceUnit._053_
+ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._075_ sky130_fd_sc_hd__mux2_1
XFILLER_9_125 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_9_169 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_13_110 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_13_165 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_36_213 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_44_290 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_8_191 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_42_205 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XuartUnit.fifoTX._171_ net59 uartUnit.fifoTX._037_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[3\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_27_213 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XuartUnit.uartTxUnit._148_ uartUnit.uartTxUnit.send_byte\[5\] net5 uartUnit.uartTxUnit._035_
+ net16 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._016_ sky130_fd_sc_hd__o211a_1
XuartUnit.uartTxUnit._079_ net10 vssd1 vssd1 vccd1 vccd1 uartUnit.uartTxUnit._041_
+ sky130_fd_sc_hd__inv_2
XFILLER_10_124 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_12_20 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_5_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XFILLER_12_97 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_33_249 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XaluUnit._283_ aluUnit.i_data_b\[4\] aluUnit.i_data_a\[4\] aluUnit._133_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._049_ sky130_fd_sc_hd__nand3_1
XFILLER_38_3 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_277 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_238 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XuartUnit.fifoTX._154_ net59 uartUnit.fifoTX._020_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[1\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._085_ uartUnit.fifoTX.array\[2\]\[7\] alu_uart_interfaceUnit.o_data_to_write\[7\]
+ uartUnit.fifoTX._046_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX._009_ sky130_fd_sc_hd__mux2_1
XFILLER_2_197 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_347 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._266_ net21 net31 aluUnit._131_ vssd1 vssd1 vccd1 vccd1 aluUnit._033_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_31_258 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XaluUnit._197_ aluUnit.i_data_a\[0\] net29 aluUnit._124_ aluUnit._129_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._130_ sky130_fd_sc_hd__o22a_1
XuartUnit.uartRxUnit._111_ uartUnit.uartRxUnit._030_ uartUnit.uartRxUnit._058_ net41
+ vssd1 vssd1 vccd1 vccd1 uartUnit.uartRxUnit._059_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_22_214 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Left_57 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_18_41 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_328 vssd1 vccd1 sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_73 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_34_51 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_1
XuartUnit.fifoTX._137_ net58 uartUnit.fifoTX._003_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.array\[2\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XuartUnit.fifoTX._068_ uartUnit.fifoTX.array\[0\]\[0\] uartUnit.fifoTX.array\[1\]\[0\]
+ uartUnit.fifoTX.array\[2\]\[0\] uartUnit.fifoTX.array\[3\]\[0\] uartUnit.fifoTX._000_
+ uartUnit.fifoTX._001_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoTX.o_data_to_read\[0\]
+ sky130_fd_sc_hd__mux4_1
XFILLER_7_289 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_7_256 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XaluUnit._249_ net23 net32 aluUnit._133_ vssd1 vssd1 vccd1 vccd1 aluUnit._017_ sky130_fd_sc_hd__nand3_1
XaluUnit._318_ aluUnit._076_ aluUnit._078_ aluUnit._080_ aluUnit._081_ vssd1 vssd1
+ vccd1 vccd1 aluUnit._082_ sky130_fd_sc_hd__or4b_1
Xfanout6 uartUnit.uartTxUnit._058_ vssd1 vssd1 vccd1 vccd1 net6 sky130_fd_sc_hd__buf_2
XFILLER_29_105 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_29_149 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
Xalu_uart_interfaceUnit._191_ net47 alu_uart_interfaceUnit._003_ vssd1 vssd1 vccd1
+ vccd1 alu_uart_interfaceUnit.state\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_281 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_20_3 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_26_108 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__fill_2
XFILLER_34_141 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
XFILLER_19_193 vccd1 vssd1 vccd1 vssd1 sky130_ef_sc_hd__decap_12
Xalu_uart_interfaceUnit._174_ alu_uart_interfaceUnit.o_data_to_write\[1\] aluUnit.o_alu_result\[1\]
+ alu_uart_interfaceUnit._059_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit._083_
+ sky130_fd_sc_hd__mux2_1
XFILLER_31_30 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_8
XFILLER_31_63 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_4
XFILLER_48_277 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XFILLER_16_141 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_6
XFILLER_16_163 vssd1 vssd1 vccd1 vccd1 sky130_fd_sc_hd__decap_3
XuartUnit.fifoRX._098_ uartUnit.fifoRX.array\[1\]\[2\] uartUnit.fifoRX.i_data_to_write\[2\]
+ uartUnit.fifoRX._048_ vssd1 vssd1 vccd1 vccd1 uartUnit.fifoRX._020_ sky130_fd_sc_hd__mux2_1
XuartUnit.fifoRX._167_ net50 uartUnit.fifoRX._033_ vssd1 vssd1 vccd1 vccd1 alu_uart_interfaceUnit.i_fifo_rx_empty
+ sky130_fd_sc_hd__dfxtp_1
.ends
